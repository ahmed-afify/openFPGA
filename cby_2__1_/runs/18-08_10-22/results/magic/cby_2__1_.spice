* NGSPICE file created from cby_2__1_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

.subckt cby_2__1_ ccff_head ccff_tail chany_in_0_ chany_in_10_ chany_in_11_ chany_in_12_
+ chany_in_13_ chany_in_14_ chany_in_15_ chany_in_16_ chany_in_17_ chany_in_1_ chany_in_2_
+ chany_in_3_ chany_in_4_ chany_in_5_ chany_in_6_ chany_in_7_ chany_in_8_ chany_in_9_
+ chany_out_0_ chany_out_10_ chany_out_11_ chany_out_12_ chany_out_13_ chany_out_14_
+ chany_out_15_ chany_out_16_ chany_out_17_ chany_out_1_ chany_out_2_ chany_out_3_
+ chany_out_4_ chany_out_5_ chany_out_6_ chany_out_7_ chany_out_8_ chany_out_9_ left_grid_pin_1_
+ left_grid_pin_5_ left_grid_pin_9_ pReset prog_clk right_grid_pin_0_ right_grid_pin_10_
+ right_grid_pin_12_ right_grid_pin_14_ right_grid_pin_2_ right_grid_pin_4_ right_grid_pin_6_
+ right_grid_pin_8_ VPWR VGND
XFILLER_22_166 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_26_85 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_34 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_33_206 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_21 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_198 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_99 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_4_0_prog_clk clkbuf_2_2_0_prog_clk/X clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_11_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_106 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_74 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_12 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_98 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_75 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_13 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_105 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_218 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_104 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_196 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_64 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_24 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_110 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_33 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_87 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_102 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_25 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_109 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_11 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_36_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_32 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_15_8 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_144 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_99 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_122 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_2_1_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XPHY_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_57 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_32 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__12__A chany_in_10_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_89 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_3 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_89 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_77 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_11 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_3_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_34_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_45 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_34 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__20__A chany_in_1_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_211 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_134 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_45 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_104 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_148 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_38 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__15__A chany_in_13_ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_46 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_37 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_13 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__23__A chany_in_4_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_56 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_187 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ ccff_tail mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset
+ clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_71 VGND VPWR sky130_fd_sc_hd__fill_2
X_28_ chany_in_9_ chany_out_9_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_29_56 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_14 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__18__A chany_in_16_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_47 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_146 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_109 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_15 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__26__A chany_in_7_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_58 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_49 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_192 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_3_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_27_ chany_in_8_ chany_out_8_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_28_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_26 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_150 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_36 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_29 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_17_220 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_0_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xmem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_61 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_190 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_92 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_127 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_171 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_34_69 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_51 VGND VPWR sky130_fd_sc_hd__decap_8
X_26_ chany_in_7_ chany_out_7_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_28_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_93 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_09_ _09_/HI right_grid_pin_2_ VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_38 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_192 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_37 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_70 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_50 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_2_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_21_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_140 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_166 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_202 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_16 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_96 VGND VPWR sky130_fd_sc_hd__fill_2
X_25_ chany_in_6_ chany_out_6_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_36_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_124 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_72 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_61 VGND VPWR sky130_fd_sc_hd__decap_3
X_08_ _08_/HI right_grid_pin_14_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_34_127 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_70 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_190 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_119 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_130 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_82 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_171 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_49 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_82 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_134 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_148 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_70 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_9 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_50 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_17 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_93 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_37_125 VGND VPWR sky130_fd_sc_hd__decap_12
X_24_ chany_in_5_ chany_out_5_ VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_136 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_202 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_139 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_117 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_147 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_106 VGND VPWR sky130_fd_sc_hd__fill_2
X_07_ _07_/HI right_grid_pin_12_ VGND VPWR sky130_fd_sc_hd__conb_1
XPHY_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_150 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_142 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_146 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_105 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_82 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_64 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_62 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_29 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_17 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_137 VGND VPWR sky130_fd_sc_hd__decap_12
X_23_ chany_in_4_ chany_out_4_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_34_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_61 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_148 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_50 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_41 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_06_ _06_/HI right_grid_pin_10_ VGND VPWR sky130_fd_sc_hd__conb_1
XPHY_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_62 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_42 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_29 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_213 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_40 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_202 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_94 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_1_0_prog_clk clkbuf_2_0_0_prog_clk/X clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_4_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_150 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_149 VGND VPWR sky130_fd_sc_hd__decap_6
X_22_ chany_in_3_ chany_out_3_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_24_73 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_95 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_53 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_05_ _05_/HI right_grid_pin_0_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_130 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_74 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_218 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_166 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_87 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_62 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_11 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_88 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_106 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_85 VGND VPWR sky130_fd_sc_hd__decap_6
X_21_ chany_in_2_ chany_out_2_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_6_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_30 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_142 VGND VPWR sky130_fd_sc_hd__decap_12
X_04_ _04_/HI left_grid_pin_1_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_24_142 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_178 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_99 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_86 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_64 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_105 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_108 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_130 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_54 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_97 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_20 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_118 VGND VPWR sky130_fd_sc_hd__decap_6
X_20_ chany_in_1_ chany_out_1_ VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_68 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_107 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_42 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XANTENNA_mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_66 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_22 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_11 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_206 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_30 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_184 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_03_ _03_/HI left_grid_pin_5_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_121 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_3_4_0_prog_clk_A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_10 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_121 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_135 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_202 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_172 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_142 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_208 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_123 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_0_0_prog_clk clkbuf_2_0_0_prog_clk/X clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_6_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_218 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_42 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_141 VGND VPWR sky130_fd_sc_hd__decap_12
X_02_ _02_/HI left_grid_pin_9_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_24_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_65 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_32 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_21 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_67 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_135 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_220 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_35_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_54 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_123 VGND VPWR sky130_fd_sc_hd__fill_2
X_01_ _01_/HI right_grid_pin_8_ VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_89 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_91 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_101 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_77 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_196 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_122 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_180 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__13__A chany_in_11_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_154 VGND VPWR sky130_fd_sc_hd__decap_12
X_00_ _00_/HI right_grid_pin_6_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_35 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_89 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_13 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__21__A chany_in_2_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_171 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_120 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__16__A chany_in_14_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_208 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_178 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_58 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_104 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_57 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_23 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_100 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_103 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_9 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__24__A chany_in_5_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_93 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__19__A chany_in_17_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_47 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_147 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_206 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_36 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_25 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_128 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_220 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_190 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_116 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__27__A chany_in_8_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_8 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_25 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_16 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_123 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_115 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_72 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_118 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_159 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_9 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_118 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_58 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_218 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_184 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_25 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_213 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_15 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_50 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_127 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_105 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_29 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_81 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_126 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_91 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_0_0_prog_clk_A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_103 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_202 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_70 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_139 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_81 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_39 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_9 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_80 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_113 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_5_0_prog_clk_A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_8 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_159 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_71 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_60 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_64 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_151 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_51 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_28 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_17 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_63 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_161 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_194 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_42 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_29 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_105 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_72 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_105 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_215 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_163 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_211 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_111 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_148 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_184 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_87 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_202 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_117 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_117 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_7 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_73 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_175 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_109 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_112 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_215 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_9 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_32 VGND VPWR sky130_fd_sc_hd__fill_2
X_19_ chany_in_17_ chany_out_17_ VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_62 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_40 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_30 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_141 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_73 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_122 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_99 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_75 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_36_129 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_19 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_107 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_74 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_56 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_124 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_20 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_117 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_66 VGND VPWR sky130_fd_sc_hd__decap_12
X_18_ chany_in_16_ chany_out_16_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_52 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_42 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_131 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_171 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_119 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_53 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_11 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_122 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_136 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_12 VGND VPWR sky130_fd_sc_hd__fill_2
X_17_ chany_in_15_ chany_out_15_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_33_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_78 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_54 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_154 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_220 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_168 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_97 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_65 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_44 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_22 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_65 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_21 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_89 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_11 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_115 VGND VPWR sky130_fd_sc_hd__decap_6
X_16_ chany_in_14_ chany_out_14_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_26_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_57 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_66 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_77 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_184 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_7_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_14_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_206 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_143 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_66 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_66 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_220 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_1_0_prog_clk_A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_190 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_105 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__11__A chany_in_0_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_109 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_15_ chany_in_13_ chany_out_13_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_145 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_215 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_3_6_0_prog_clk_A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_89 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_218 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_155 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_67 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_78 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__14__A chany_in_12_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_44 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_47 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_14 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_57 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_154 VGND VPWR sky130_fd_sc_hd__decap_12
X_14_ chany_in_12_ chany_out_12_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__22__A chany_in_3_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_67 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_190 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__17__A chany_in_15_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_57 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_167 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_123 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_68 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_24 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_17 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_123 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_59 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__25__A chany_in_6_ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_218 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_69 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_25 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_14 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_133 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_16 VGND VPWR sky130_fd_sc_hd__decap_12
X_13_ chany_in_11_ chany_out_11_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_79 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_30_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_94 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_28 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_110 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__28__A chany_in_9_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_179 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_69 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_190 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_58 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_127 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_6_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_16_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_149 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_108 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_131 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_50 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_28 VGND VPWR sky130_fd_sc_hd__decap_3
X_12_ chany_in_10_ chany_out_10_ VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_137 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_15 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_16 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_59 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_15 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_61 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_103 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_92 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_172 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_143 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_220 VGND VPWR sky130_fd_sc_hd__fill_1
X_11_ chany_in_0_ chany_out_0_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_71 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_215 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_123 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_20_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_60 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_115 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_18 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_15 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_118 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_155 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_96 VGND VPWR sky130_fd_sc_hd__decap_3
X_10_ _10_/HI right_grid_pin_4_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_202 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_202 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_180 VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_2_3_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_93 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_135 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_105 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_30 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_28 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_167 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_42 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_133 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_5_0_prog_clk clkbuf_2_2_0_prog_clk/X clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XPHY_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_28 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_83 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_50 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_50 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_84 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_128 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_60 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_64 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_51 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_179 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_190 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_101 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_105 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_3_2_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_44 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_84 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_40 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_200 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_19 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_9 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_184 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_3_7_0_prog_clk_A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_26_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_109 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_172 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_41 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_87 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_212 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_97 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_2_2_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_4_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_152 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_19_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_41 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_30 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_111 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_152 VGND VPWR sky130_fd_sc_hd__fill_1
.ends
