* NGSPICE file created from cby_2__1_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

.subckt cby_2__1_ chany_in_0_ left_grid_pin_1_ chany_in_14_ chany_in_8_ pReset chany_in_3_
+ chany_in_7_ ccff_head chany_in_2_ right_grid_pin_12_ chany_out_10_ chany_in_12_
+ chany_in_9_ chany_in_16_ right_grid_pin_0_ chany_out_7_ chany_out_0_ chany_in_4_
+ chany_out_4_ chany_out_16_ chany_in_17_ left_grid_pin_5_ right_grid_pin_6_ chany_in_15_
+ prog_clk chany_out_13_ ccff_tail chany_in_13_ right_grid_pin_10_ chany_in_10_ chany_out_17_
+ chany_out_12_ right_grid_pin_8_ right_grid_pin_14_ chany_out_2_ chany_out_11_ chany_out_9_
+ chany_in_11_ chany_in_5_ chany_in_1_ chany_out_15_ chany_in_6_ chany_out_5_ right_grid_pin_2_
+ chany_out_8_ chany_out_1_ left_grid_pin_9_ right_grid_pin_4_ chany_out_14_ chany_out_6_
+ chany_out_3_ VPWR VGND
XFILLER_22_122 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_159 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_217 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_176 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_154 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_4_0_prog_clk clkbuf_3_5_0_prog_clk/A clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_11_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_117 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_74 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_56 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_20 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_156 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_86 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_10 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_188 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_64 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_66 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_132 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_190 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_179 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_65 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_58 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_10_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_208 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_21 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_11 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_9 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_177 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_144 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_152 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_99 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_144 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_89 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_103 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_2_1_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XPHY_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_125 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_77 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_103 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_117 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_80 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__12__A chany_in_10_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_13 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_3_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_29_88 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_11 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_45 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_101 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_24 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_211 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__20__A chany_in_1_ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_148 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_89 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_38 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_27 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__15__A chany_in_13_ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_46 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_35 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_57 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_24 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__23__A chany_in_4_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_187 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ ccff_tail mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset
+ clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_28_ chany_in_9_ chany_out_9_ VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA__18__A chany_in_16_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_110 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_135 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_116 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_57 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_160 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_56 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__26__A chany_in_7_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_48 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_211 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_91 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_27 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_57 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_3_3_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_69 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_90 VGND VPWR sky130_fd_sc_hd__fill_2
X_27_ chany_in_8_ chany_out_8_ VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_9 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_15 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_136 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_103 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_27 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_0_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_17_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_190 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_39 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_25 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_208 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_3 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_47 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_14 VGND VPWR sky130_fd_sc_hd__fill_2
X_26_ chany_in_7_ chany_out_7_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_51 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_60 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_93 VGND VPWR sky130_fd_sc_hd__decap_12
X_09_ _09_/HI right_grid_pin_2_ VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_15 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_118 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_2_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_26_15 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_166 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_147 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_15 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_16 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_17 VGND VPWR sky130_fd_sc_hd__decap_12
X_25_ chany_in_6_ chany_out_6_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_190 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_135 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_72 VGND VPWR sky130_fd_sc_hd__decap_12
X_08_ _08_/HI right_grid_pin_14_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_34_127 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_190 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_28 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_203 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_200 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_39 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_129 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_162 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_71 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_37_125 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_29 VGND VPWR sky130_fd_sc_hd__fill_2
X_24_ chany_in_5_ chany_out_5_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_86 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_139 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_07_ _07_/HI right_grid_pin_12_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_172 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_128 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_120 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_109 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_120 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_212 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_29 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_83 VGND VPWR sky130_fd_sc_hd__decap_4
X_23_ chany_in_4_ chany_out_4_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_98 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_115 VGND VPWR sky130_fd_sc_hd__decap_3
X_06_ _06_/HI right_grid_pin_10_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_95 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_62 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_86 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_202 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_40 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_202 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_1_0_prog_clk clkbuf_2_0_0_prog_clk/X clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_4_32 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_34_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_149 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_22_ chany_in_3_ chany_out_3_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_29_18 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_105 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_86 VGND VPWR sky130_fd_sc_hd__decap_6
X_05_ _05_/HI right_grid_pin_0_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_52 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_30 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_218 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_166 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_200 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_19 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_111 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_52 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_40 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_44 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_53 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_106 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_63 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_202 VGND VPWR sky130_fd_sc_hd__decap_12
X_21_ chany_in_2_ chany_out_2_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_28_139 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_106 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_74 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_41 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_95 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_120 VGND VPWR sky130_fd_sc_hd__fill_2
X_04_ _04_/HI left_grid_pin_1_ VGND VPWR sky130_fd_sc_hd__conb_1
XPHY_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_42 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_153 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_156 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_63 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_212 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_145 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_52 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_118 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_20_ chany_in_1_ chany_out_1_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_36_151 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_3_206 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_03_ _03_/HI left_grid_pin_5_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_27_184 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_140 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_4_0_prog_clk_A clkbuf_3_5_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_87 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_165 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_117 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_68 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_208 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_123 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_87 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_0_0_prog_clk clkbuf_2_0_0_prog_clk/X clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_6_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_218 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_111 VGND VPWR sky130_fd_sc_hd__decap_3
X_02_ _02_/HI left_grid_pin_9_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_122 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_99 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_103 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_177 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_22 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_206 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_184 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_87 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_220 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_135 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_202 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_11 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_35_87 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_54 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_131 VGND VPWR sky130_fd_sc_hd__decap_12
X_01_ _01_/HI right_grid_pin_8_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_120 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_178 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_56 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_34 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_115 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_123 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_148 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_218 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_66 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_196 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_99 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_44 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_24 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_67 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_27 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__13__A chany_in_11_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_99 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_11 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_143 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_78 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_45 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_36 VGND VPWR sky130_fd_sc_hd__decap_12
X_00_ _00_/HI right_grid_pin_6_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_132 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_105 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_78 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_105 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__21__A chany_in_2_ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_160 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__16__A chany_in_14_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_56 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_178 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_159 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_79 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_34 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_155 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_111 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_103 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_144 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__24__A chany_in_5_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_191 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_180 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_15_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__19__A chany_in_17_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_7 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_32_57 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_24 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_117 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_172 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_90 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_15 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_190 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__27__A chany_in_8_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_36 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_14 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_101 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_46 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_167 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_200 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_148 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_48 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_70 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_15 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_80 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_184 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_93 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_202 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_206 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_179 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_190 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_124 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_38 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_160 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_82 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_15 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_196 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_15 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_200 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_28 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_218 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_62 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_3_0_0_prog_clk_A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_103 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_49 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_70 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_136 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_172 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_128 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_212 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_3_5_0_prog_clk_A clkbuf_3_5_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_171 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_115 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_71 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_60 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_93 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_118 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_23_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_51 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_61 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_147 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_16_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_117 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_194 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_86 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_18 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_127 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_17 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_127 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_72 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_105 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_215 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_196 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_211 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_111 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_19 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_206 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_61 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_62 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_52 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_202 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_139 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_106 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_29 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_128 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_117 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_73 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_131 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_62 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_150 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_51 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_120 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_30 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_215 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_32 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_19_ chany_in_17_ chany_out_17_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_95 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_51 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_218 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_30_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_97 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_74 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_64 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_113 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_190 VGND VPWR sky130_fd_sc_hd__decap_12
X_18_ chany_in_16_ chany_out_16_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_175 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_41 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_86 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_119 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_130 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_97 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_152 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_3 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_17_ chany_in_15_ chany_out_15_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_98 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_143 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_97 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_28_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_172 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_120 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_65 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_142 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_54 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_10 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_64 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_148 VGND VPWR sky130_fd_sc_hd__decap_12
X_16_ chany_in_14_ chany_out_14_ VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_26_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_66 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_55 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_11 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_155 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_65 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_7_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_29_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_206 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_66 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_55 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_179 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_124 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_220 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_1_0_prog_clk_A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_32 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_105 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__11__A chany_in_0_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_15_ chany_in_13_ chany_out_13_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_78 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_99 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_11 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_123 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_200 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_77 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_22 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_215 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_3_6_0_prog_clk_A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_59 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_218 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_196 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_67 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_147 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__14__A chany_in_12_ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_56 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_114 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_44 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_191 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_92 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_14_ chany_in_12_ chany_out_12_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_220 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__22__A chany_in_3_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_212 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__17__A chany_in_15_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_24 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_112 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_68 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_148 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__25__A chany_in_6_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_15 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_218 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_14 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_107 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_13_ chany_in_11_ chany_out_11_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_17_47 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_14 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_39 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_48 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_15 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__28__A chany_in_9_ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_135 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_80 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_69 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_190 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_58 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_25_47 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_14 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_160 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_6_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_16_190 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_50 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_26 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_12_ chany_in_10_ chany_out_10_ VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_91 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_15 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_103 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_59 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_70 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_201 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__decap_12
X_11_ chany_in_0_ chany_out_0_ VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_26 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_15 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_123 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_35_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_93 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_104 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_82 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_92 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_74 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_96 VGND VPWR sky130_fd_sc_hd__decap_12
X_10_ _10_/HI right_grid_pin_4_ VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_121 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_202 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_139 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_3_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_113 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_61 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_39 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_116 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_19 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_152 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_86 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_5_0_prog_clk clkbuf_3_5_0_prog_clk/A clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_12_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_133 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_166 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_9 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_18 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_17 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_202 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_34_161 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_109 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_15_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_197 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_52 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_2_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_108 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_29 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_61 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_148 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_85 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_173 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_118 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_95 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_7_0_prog_clk_A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_176 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_140 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_205 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_19 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_85 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_108 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_51 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_2_2_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_3_5_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_20_64 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_185 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_152 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_19_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_53 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_111 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_152 VGND VPWR sky130_fd_sc_hd__fill_1
.ends
