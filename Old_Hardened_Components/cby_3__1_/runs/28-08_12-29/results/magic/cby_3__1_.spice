* NGSPICE file created from cby_3__1_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

.subckt cby_3__1_ ccff_head ccff_tail chany_bottom_in[0] chany_bottom_in[1] chany_bottom_in[2]
+ chany_bottom_in[3] chany_bottom_in[4] chany_bottom_in[5] chany_bottom_in[6] chany_bottom_in[7]
+ chany_bottom_in[8] chany_bottom_out[0] chany_bottom_out[1] chany_bottom_out[2] chany_bottom_out[3]
+ chany_bottom_out[4] chany_bottom_out[5] chany_bottom_out[6] chany_bottom_out[7]
+ chany_bottom_out[8] chany_top_in[0] chany_top_in[1] chany_top_in[2] chany_top_in[3]
+ chany_top_in[4] chany_top_in[5] chany_top_in[6] chany_top_in[7] chany_top_in[8]
+ chany_top_out[0] chany_top_out[1] chany_top_out[2] chany_top_out[3] chany_top_out[4]
+ chany_top_out[5] chany_top_out[6] chany_top_out[7] chany_top_out[8] left_grid_pin_1_
+ left_grid_pin_5_ left_grid_pin_9_ pReset prog_clk right_grid_pin_0_ right_grid_pin_10_
+ right_grid_pin_12_ right_grid_pin_14_ right_grid_pin_2_ right_grid_pin_4_ right_grid_pin_6_
+ right_grid_pin_8_ VPWR VGND
Xmem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_166 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_166 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_56 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_129 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_247 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_280 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_206 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_154 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_4_0_prog_clk clkbuf_2_2_0_prog_clk/X clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_11_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_286 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_323 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_67 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_315 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_359 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_208 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_98 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_230 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_341 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_68 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_148 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_77 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_259 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_196 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_292 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_262 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_276 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_298 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_335 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_324 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_57 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_261 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_79 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_327 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_349 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_242 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_393 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_113 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_190 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_116 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_359 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_131 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_23_33 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_274 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_101 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_35 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_244 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_226 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_19_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_328 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_332 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_361 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_2_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_13_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_324 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_140 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_128 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_349 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_239 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_91 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__12__A chany_top_in[7] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_253 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_238 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_234 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_245 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_304 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_219 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_208 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_15 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_3_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_19_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_318 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__20__A chany_bottom_in[8] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_211 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_373 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__15__A chany_top_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_108 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_159 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_27 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_68 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_287 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_169 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_276 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_202 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_57 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__23__A chany_bottom_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_324 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_60 VGND VPWR sky130_fd_sc_hd__fill_1
X_28_ chany_bottom_in[0] chany_top_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ ccff_tail mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset
+ clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA__18__A chany_top_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_253 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_110 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_168 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_345 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_385 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_90 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_105 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_108 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_318 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__26__A chany_bottom_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_299 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_288 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_69 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_3_3_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_303 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_27_ chany_bottom_in[1] chany_top_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_350 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_265 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_232 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_15 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_48 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_125 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_324 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_357 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_60 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_106 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_371 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_102 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_1_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_220 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_23_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_37 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_223 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_278 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_223 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_248 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_208 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__decap_12
X_26_ chany_bottom_in[2] chany_top_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_362 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_123 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_137 VGND VPWR sky130_fd_sc_hd__decap_12
X_09_ _09_/HI right_grid_pin_2_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_21_354 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_365 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_16_137 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_332 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_369 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_129 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_192 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_391 VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_2_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_5_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_173 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_133 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_144 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_81 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_383 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_342 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_73 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_40 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_257 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_205 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_272 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_238 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_260 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_74 VGND VPWR sky130_fd_sc_hd__decap_12
X_25_ chany_bottom_in[3] chany_top_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_24_374 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_245 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_168 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
X_08_ _08_/HI right_grid_pin_14_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_25_149 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_311 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_149 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_337 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_300 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_171 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_196 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_354 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_255 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_85 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_269 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_140 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_184 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_240 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_19_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_243 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_272 VGND VPWR sky130_fd_sc_hd__decap_3
X_24_ chany_bottom_in[4] chany_top_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_86 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_386 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_60 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_106 VGND VPWR sky130_fd_sc_hd__decap_12
X_07_ _07_/HI right_grid_pin_12_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_21_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_249 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_117 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_74 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_109 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_153 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_127 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_215 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_248 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_152 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_281 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_318 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_72 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_255 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_98 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_362 VGND VPWR sky130_fd_sc_hd__decap_12
X_23_ chany_bottom_in[5] chany_top_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_148 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_354 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_118 VGND VPWR sky130_fd_sc_hd__decap_6
X_06_ _06_/HI right_grid_pin_10_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_21_357 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_379 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_324 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_62 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_42 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_165 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_125 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_121 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_154 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_301 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_367 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_172 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_1_0_prog_clk clkbuf_2_0_0_prog_clk/X clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_23_216 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_120 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_220 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_231 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_208 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_267 VGND VPWR sky130_fd_sc_hd__decap_8
X_22_ chany_bottom_in[6] chany_top_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_18_374 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_300 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_97 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_19_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_05_ _05_/HI right_grid_pin_0_ VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_336 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_218 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_141 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_54 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_351 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_98 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_137 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_133 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_357 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_280 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_86 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_231 VGND VPWR sky130_fd_sc_hd__fill_1
X_21_ chany_bottom_in[7] chany_top_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_18_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_345 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_249 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_367 VGND VPWR sky130_fd_sc_hd__decap_12
X_04_ _04_/HI left_grid_pin_1_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_21_348 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_337 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_53 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_145 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_355 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_292 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_207 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_98 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_288 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_276 VGND VPWR sky130_fd_sc_hd__decap_12
X_20_ chany_bottom_in[8] chany_top_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_44 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XANTENNA_mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_31 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_42 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_294 VGND VPWR sky130_fd_sc_hd__fill_1
X_03_ _03_/HI left_grid_pin_5_ VGND VPWR sky130_fd_sc_hd__conb_1
Xmem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_151 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_4_0_prog_clk_A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_349 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_393 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_121 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_102 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_312 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_117 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_161 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_271 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_208 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_263 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_112 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_156 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_245 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_0_0_prog_clk clkbuf_2_0_0_prog_clk/X clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_6_215 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_255 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_54 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_391 VGND VPWR sky130_fd_sc_hd__decap_3
X_02_ _02_/HI left_grid_pin_9_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_21_306 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_66 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_111 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_188 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_169 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_291 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_261 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_393 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_231 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_224 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_257 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_90 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_312 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_337 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_68 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_326 VGND VPWR sky130_fd_sc_hd__fill_1
X_01_ _01_/HI right_grid_pin_8_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_131 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_381 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_78 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_322 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_170 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_270 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_273 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_24 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_236 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_202 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__13__A chany_top_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_324 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_34 VGND VPWR sky130_fd_sc_hd__fill_2
X_00_ _00_/HI right_grid_pin_6_ VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_393 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_385 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_24 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_57 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_182 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_359 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_337 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__21__A chany_bottom_in[7] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_131 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_230 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__16__A chany_top_in[3] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_373 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_104 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_68 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_306 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA__24__A chany_bottom_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_265 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_93 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__19__A chany_top_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_15_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_353 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_128 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_69 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_194 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_349 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_172 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_283 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_242 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_385 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_15 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__27__A chany_bottom_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_227 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_219 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_318 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_329 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_362 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_288 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_123 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_178 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_50 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_72 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_15 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_115 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_17 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_365 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_15 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_328 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_93 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_342 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_202 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_128 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_224 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_235 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_257 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_227 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_352 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_201 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_330 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_341 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_326 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_60 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_318 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_362 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_351 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_25_211 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_233 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_28 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_3_0_0_prog_clk_A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_342 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_257 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_70 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_312 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_323 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_28 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_106 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_393 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_93 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_220 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_231 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_242 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_190 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_3_5_0_prog_clk_A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_311 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_366 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_82 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_108 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_211 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_269 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_71 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_60 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_391 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_324 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_162 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_361 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_132 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_136 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_143 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_287 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_323 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_205 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_227 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_227 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_53 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_40 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_245 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_330 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_94 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_72 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_61 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_281 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_141 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_318 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_144 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_310 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_335 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_151 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_206 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_187 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_52 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_257 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_205 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_117 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_73 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_62 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_345 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_293 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_172 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_304 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_315 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_337 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_131 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_330 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_385 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_52 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_223 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_278 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_21 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_32 VGND VPWR sky130_fd_sc_hd__decap_12
X_19_ chany_top_in[0] chany_bottom_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_237 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_259 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_74 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_218 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_66 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_64 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_343 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_365 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_379 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_63 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_63 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_52 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_324 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_357 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_17_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_135 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_249 VGND VPWR sky130_fd_sc_hd__decap_12
X_18_ chany_top_in[1] chany_bottom_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_0_304 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_31 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_227 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_249 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_42 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_131 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_260 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_78 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_204 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_270 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_358 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_53 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_64 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_75 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_369 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_328 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_199 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_125 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_302 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_147 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_56 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_140 VGND VPWR sky130_fd_sc_hd__decap_12
X_17_ chany_top_in[2] chany_bottom_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_16_206 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_54 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_87 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_143 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_15_283 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_168 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_202 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_231 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_24 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_348 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_54 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_65 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_337 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_370 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_318 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_45 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_56 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_134 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_362 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_358 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_152 VGND VPWR sky130_fd_sc_hd__fill_1
X_16_ chany_top_in[3] chany_bottom_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_25_218 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_99 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_273 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_23 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_7_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_17_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_55 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_66 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_382 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_220 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_297 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_353 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_1_0_prog_clk_A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_135 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_146 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_374 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_105 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_105 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__11__A chany_top_in[8] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_227 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_370 VGND VPWR sky130_fd_sc_hd__decap_12
X_15_ chany_top_in[4] chany_bottom_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_271 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_34 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_123 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_137 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_15 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_255 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_288 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_6_0_prog_clk_A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_281 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_207 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_336 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_347 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_23_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_91 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_56 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_56 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__14__A chany_top_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_67 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_38 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_111 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_365 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_324 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_117 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_140 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_239 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_15 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_382 VGND VPWR sky130_fd_sc_hd__decap_12
X_14_ chany_top_in[5] chany_bottom_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__22__A chany_bottom_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_231 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_201 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_149 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__17__A chany_top_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_227 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_359 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_230 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_318 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_57 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_68 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_300 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_48 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__25__A chany_bottom_in[3] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_332 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_170 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_129 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_60 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_339 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_306 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_140 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_13_ chany_top_in[6] chany_bottom_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_287 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_92 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_106 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_28 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_15 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__28__A chany_bottom_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_393 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_242 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_91 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_58 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_289 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_367 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_6_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_23_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_105 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_120 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_48 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_178 VGND VPWR sky130_fd_sc_hd__decap_12
X_12_ chany_top_in[7] chany_bottom_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_288 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_266 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_277 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_299 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_181 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_280 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_306 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_339 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_276 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_59 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_224 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_257 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_324 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_357 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_353 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_39 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_109 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_135 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_330 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__decap_4
X_11_ chany_top_in[8] chany_bottom_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_38 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_193 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_160 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_226 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_215 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_230 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_266 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_222 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_362 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_148 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_280 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_324 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_140 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_361 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_52 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_276 VGND VPWR sky130_fd_sc_hd__decap_12
X_10_ _10_/HI right_grid_pin_4_ VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_180 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_117 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_257 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_75 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_3_0_prog_clk clkbuf_0_prog_clk/X clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_9_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_238 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_227 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_260 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_220 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_385 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_212 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_61 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_330 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_374 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_292 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_381 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_163 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_174 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_100 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_144 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_73 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_5_0_prog_clk clkbuf_2_2_0_prog_clk/X clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_18_255 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_288 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_96 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_250 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_361 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_73 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_386 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_290 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_312 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_62 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_393 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_135 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_178 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_3_2_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_86 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_262 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_85 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_21 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_32 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_335 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_228 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_328 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_324 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_52 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_74 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_3_7_0_prog_clk_A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_261 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_132 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_320 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_44 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_227 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_234 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_274 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_366 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_311 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_226 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_215 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_2_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_16_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_160 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_318 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_391 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_273 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
