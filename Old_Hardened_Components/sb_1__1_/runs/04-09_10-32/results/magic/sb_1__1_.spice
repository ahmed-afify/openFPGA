* NGSPICE file created from sb_1__1_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

.subckt sb_1__1_ bottom_left_grid_pin_13_ bottom_right_grid_pin_11_ ccff_head ccff_tail
+ chanx_left_in[0] chanx_left_in[1] chanx_left_in[2] chanx_left_in[3] chanx_left_in[4]
+ chanx_left_in[5] chanx_left_in[6] chanx_left_in[7] chanx_left_in[8] chanx_left_out[0]
+ chanx_left_out[1] chanx_left_out[2] chanx_left_out[3] chanx_left_out[4] chanx_left_out[5]
+ chanx_left_out[6] chanx_left_out[7] chanx_left_out[8] chanx_right_in[0] chanx_right_in[1]
+ chanx_right_in[2] chanx_right_in[3] chanx_right_in[4] chanx_right_in[5] chanx_right_in[6]
+ chanx_right_in[7] chanx_right_in[8] chanx_right_out[0] chanx_right_out[1] chanx_right_out[2]
+ chanx_right_out[3] chanx_right_out[4] chanx_right_out[5] chanx_right_out[6] chanx_right_out[7]
+ chanx_right_out[8] chany_bottom_in[0] chany_bottom_in[1] chany_bottom_in[2] chany_bottom_in[3]
+ chany_bottom_in[4] chany_bottom_in[5] chany_bottom_in[6] chany_bottom_in[7] chany_bottom_in[8]
+ chany_bottom_out[0] chany_bottom_out[1] chany_bottom_out[2] chany_bottom_out[3]
+ chany_bottom_out[4] chany_bottom_out[5] chany_bottom_out[6] chany_bottom_out[7]
+ chany_bottom_out[8] chany_top_in[0] chany_top_in[1] chany_top_in[2] chany_top_in[3]
+ chany_top_in[4] chany_top_in[5] chany_top_in[6] chany_top_in[7] chany_top_in[8]
+ chany_top_out[0] chany_top_out[1] chany_top_out[2] chany_top_out[3] chany_top_out[4]
+ chany_top_out[5] chany_top_out[6] chany_top_out[7] chany_top_out[8] left_bottom_grid_pin_12_
+ left_top_grid_pin_10_ pReset prog_clk right_bottom_grid_pin_12_ right_top_grid_pin_10_
+ top_left_grid_pin_13_ top_right_grid_pin_11_ VPWR VGND
XFILLER_22_122 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_63 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_111 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_56 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_87 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_158 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_97 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_42 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_143 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_77 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_4_0_prog_clk clkbuf_3_5_0_prog_clk/A clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_1_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_64 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_78 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_54 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_43 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_16_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_120 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_75 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_54 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_44 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_99 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_26_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_146 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_150 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_138 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_59 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_11 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_16_133 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_89 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_125 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_1_0_prog_clk clkbuf_1_0_0_prog_clk/X clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_26_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_11 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_103 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_118 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_154 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__12__A chanx_right_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_23 VGND VPWR sky130_fd_sc_hd__fill_2
X_29_ chany_top_in[0] chany_bottom_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
Xclkbuf_3_3_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_20_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_57 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__20__A chanx_left_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_115 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__15__A chanx_right_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_129 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_147 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_81 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_68 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__23__A chanx_left_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_28_ chany_top_in[1] chany_bottom_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_36 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__18__A chanx_left_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_25_146 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_47 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_22_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_116 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__31__A chany_bottom_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_142 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_26 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__26__A chany_top_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_112 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_36 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_3_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_27_ chany_top_in[2] chany_bottom_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_15 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__34__A chany_bottom_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_158 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_26 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_125 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__29__A chany_top_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_14 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_150 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_132 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_146 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_0_0_prog_clk clkbuf_1_0_0_prog_clk/X clkbuf_3_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_23_26 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_15 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_27 VGND VPWR sky130_fd_sc_hd__fill_2
X_26_ chany_top_in[4] chany_bottom_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_19_91 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_6_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_38 VGND VPWR sky130_fd_sc_hd__fill_2
X_09_ _09_/HI chanx_right_out[8] VGND VPWR sky130_fd_sc_hd__conb_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_26 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_107 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_2_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_158 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_27 VGND VPWR sky130_fd_sc_hd__fill_2
X_25_ chany_top_in[5] chany_bottom_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_19_146 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_2_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
X_08_ _08_/HI chany_bottom_out[0] VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_138 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_119 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_51 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_71 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_85 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_50 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_71 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_24_ chany_top_in[6] chany_bottom_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_73 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_103 VGND VPWR sky130_fd_sc_hd__fill_2
X_07_ _07_/HI chany_bottom_out[4] VGND VPWR sky130_fd_sc_hd__conb_1
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_83 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_124 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_146 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_95 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_23_ chanx_left_in[0] chanx_right_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_19 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_115 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_85 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_06_ _06_/HI chany_bottom_out[8] VGND VPWR sky130_fd_sc_hd__conb_1
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_95 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_51 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_40 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_129 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_154 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_121 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_158 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xclkbuf_3_1_0_prog_clk clkbuf_3_1_0_prog_clk/A clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_85 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_19 VGND VPWR sky130_fd_sc_hd__fill_2
X_22_ chanx_left_in[1] chanx_right_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_19_95 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_108 VGND VPWR sky130_fd_sc_hd__decap_8
X_05_ _05_/HI chany_top_out[0] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_85 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_30 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_41 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_133 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_151 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_42 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_1_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_30 VGND VPWR sky130_fd_sc_hd__fill_1
X_21_ chanx_left_in[2] chanx_right_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_85 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__fill_2
X_04_ _04_/HI chany_top_out[4] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_150 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_44 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_55 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_75 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_138 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_108 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_54 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_75 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_20_ chanx_left_in[4] chanx_right_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_19_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_107 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_31 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_10_44 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_77 VGND VPWR sky130_fd_sc_hd__fill_2
X_03_ _03_/HI chany_top_out[8] VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_4_0_prog_clk_A clkbuf_3_5_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_154 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_146 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_102 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_128 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_150 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_99 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_32 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_0_0_prog_clk clkbuf_3_1_0_prog_clk/A clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_25_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_89 VGND VPWR sky130_fd_sc_hd__fill_1
X_02_ _02_/HI chanx_left_out[0] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_24_122 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_44 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_125 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_143 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_89 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_146 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_11 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_99 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_7 VGND VPWR sky130_fd_sc_hd__fill_2
X_01_ _01_/HI chanx_left_out[4] VGND VPWR sky130_fd_sc_hd__conb_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_2_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_45 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_158 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_67 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__13__A chanx_right_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_154 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_00_ _00_/HI chanx_left_out[8] VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_146 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_113 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_48 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_138 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__21__A chanx_left_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__16__A chanx_right_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_13_58 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_90 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_19_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_35 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_133 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__24__A chany_top_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_125 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_158 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__19__A chanx_left_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_106 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_36 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_117 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_154 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__32__A chany_bottom_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__27__A chany_top_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_14 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_60 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_19_47 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_137 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_48 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_26 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__35__A chany_bottom_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_15 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_129 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_80 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_147 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_38 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_70 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_105 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_18 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_93 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_27 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_118 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
Xmem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XANTENNA_clkbuf_3_0_0_prog_clk_A clkbuf_3_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_82 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_70 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_125 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_70 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_85 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_117 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_146 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_5_0_prog_clk_A clkbuf_3_5_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_73 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_60 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_29 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_108 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_0_152 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_39 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_60 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_71 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_51 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_154 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_154 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_158 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_83 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_150 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_18 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_62 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_138 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_61 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_72 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_122 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_19 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_11_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_73 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_74 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_62 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_62 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_73 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_109 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_120 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_116 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_43 VGND VPWR sky130_fd_sc_hd__decap_3
X_19_ chanx_left_in[5] chanx_right_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_17_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_30 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_55 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_86 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_96 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_63 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_78 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_35_ chany_bottom_in[0] chany_top_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_22_53 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_146 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_77 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_88 VGND VPWR sky130_fd_sc_hd__fill_2
X_18_ chanx_left_in[6] chanx_right_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_156 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_119 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_64 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_133 VGND VPWR sky130_fd_sc_hd__fill_1
X_34_ chany_bottom_in[1] chany_top_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_43 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_32 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_10 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_17_ chanx_right_in[0] chanx_left_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_17_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_43 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_154 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_65 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_54 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_23_101 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_11_89 VGND VPWR sky130_fd_sc_hd__decap_4
X_33_ chany_bottom_in[2] chany_top_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_137 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
Xmem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_11_104 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_3 VGND VPWR sky130_fd_sc_hd__decap_8
X_16_ chanx_right_in[1] chanx_left_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_17_77 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_66 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_7_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_14_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_55 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_66 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_26 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_146 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_113 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_3_1_0_prog_clk_A clkbuf_3_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_116 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_32_ chany_bottom_in[4] chany_top_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_150 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_116 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__decap_3
X_15_ chanx_right_in[2] chanx_left_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_6_120 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_142 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_56 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_34 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_112 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_6_0_prog_clk_A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_67 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__14__A chanx_right_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_125 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_31_ chany_bottom_in[5] chany_top_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_150 VGND VPWR sky130_fd_sc_hd__decap_3
X_14_ chanx_right_in[4] chanx_left_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_146 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__22__A chanx_left_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__17__A chanx_right_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_49 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_36 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_90 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_156 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_35 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__30__A chany_bottom_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_57 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_68 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_137 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__25__A chany_top_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
X_30_ chany_bottom_in[6] chany_top_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_22_36 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_14 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_1_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_133 VGND VPWR sky130_fd_sc_hd__fill_1
X_13_ chanx_right_in[5] chanx_left_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_81 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_90 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__33__A chany_bottom_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_15 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__28__A chany_top_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_25_47 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_69 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_146 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_105 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_6_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_14_116 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_108 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_12_ chanx_right_in[6] chanx_left_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_17_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_80 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XFILLER_9_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_27 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__fill_1
X_11_ _11_/HI chanx_right_out[0] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_6_146 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_120 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_142 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_116 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_30 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_2_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_14_28 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_82 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_26_137 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_84 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_129 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_39 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_83 VGND VPWR sky130_fd_sc_hd__fill_2
X_10_ _10_/HI chanx_right_out[4] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_6_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_39 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_93 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_3_0_prog_clk clkbuf_2_2_0_prog_clk/A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_73 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_93 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_60 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_50 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_149 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_50 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_71 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_18 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_5_0_prog_clk clkbuf_3_5_0_prog_clk/A clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_10_133 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_7 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_50 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_85 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_72 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_19 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_40 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_106 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_16_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_95 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_146 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_138 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_2_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_108 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_53 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_84 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_118 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_3_7_0_prog_clk_A clkbuf_3_7_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_30 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_1_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_22_154 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_146 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ ccff_tail mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset
+ clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_85 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_6 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/CLK VGND VPWR
+ sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_2_0_prog_clk clkbuf_2_2_0_prog_clk/A clkbuf_3_5_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_88 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
.ends
