* NGSPICE file created from sb_0__3_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

.subckt sb_0__3_ right_bottom_grid_pin_12_ chanx_right_out[0] chanx_right_out[1] chanx_right_out[2]
+ chanx_right_out[3] chanx_right_out[4] chanx_right_out[5] chanx_right_out[6] chanx_right_out[7]
+ chanx_right_out[8] chanx_right_in[0] chanx_right_in[1] chanx_right_in[2] chanx_right_in[3]
+ chanx_right_in[4] chanx_right_in[5] chanx_right_in[6] chanx_right_in[7] chanx_right_in[8]
+ right_top_grid_pin_1_ right_top_grid_pin_3_ right_top_grid_pin_5_ right_top_grid_pin_7_
+ right_top_grid_pin_9_ right_top_grid_pin_11_ right_top_grid_pin_13_ right_top_grid_pin_15_
+ ccff_head ccff_tail bottom_left_grid_pin_1_ bottom_left_grid_pin_3_ bottom_left_grid_pin_5_
+ bottom_left_grid_pin_7_ bottom_left_grid_pin_9_ bottom_left_grid_pin_11_ bottom_left_grid_pin_13_
+ bottom_left_grid_pin_15_ prog_clk pReset chany_bottom_out[0] chany_bottom_out[1]
+ chany_bottom_out[2] chany_bottom_out[3] chany_bottom_out[4] chany_bottom_out[5]
+ chany_bottom_out[6] chany_bottom_out[7] chany_bottom_out[8] chany_bottom_in[0] chany_bottom_in[1]
+ chany_bottom_in[2] chany_bottom_in[3] chany_bottom_in[4] chany_bottom_in[5] chany_bottom_in[6]
+ chany_bottom_in[7] chany_bottom_in[8] bottom_right_grid_pin_11_ VPWR VGND
XFILLER_79_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_556 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_623 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_842 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_910 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_269 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_239 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_464 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_300 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_898 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_171 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_154_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_44 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_537 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_924 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_428 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_581 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_489 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_56_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_614 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_98 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_367 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_264 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_253 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_242 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_297 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_268 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_623 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_466 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_849 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_315 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_230 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_495 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_170 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_192 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_181 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_842 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_374 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_440 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_410 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_550 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_922 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_281 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_251 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_849 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_807 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_379 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_593 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_654 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_232 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_593 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_715 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_440 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_155_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_280 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_239 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_478 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_74 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_891 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_145_708 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_261 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_590 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_242 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_293 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_160 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_193 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_182 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_422 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_308 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_354 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_154_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_312 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_720 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_293 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_812 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_58_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_819 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_764 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_550 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_403 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_611 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_635 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_263 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_296 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_837 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_391 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_249 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_259 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_739 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_647 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_435 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_520 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_873 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_295 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_306 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_265 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_276 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_161 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_194 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_183 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_172 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_310 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_910 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_239 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_1_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_35_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_342 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_898 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_32 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_346 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_629 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_581 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_220 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_776 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_562 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_623 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_849 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_757 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_245 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_690 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_532 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_447 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_495 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_310 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_98 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_532 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_178 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_143_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_211 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_151 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_140 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_184 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_195 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_322 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_575 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_891 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_372 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_379 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_593 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_788 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_440 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_276 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_156_900 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_611 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_891 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_861 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_218 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_922 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_268 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_62 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_15_574 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_544 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_605 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_404 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_459 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_349 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_300 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_311 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_544 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_253 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_571 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_152 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_185 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_301 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_196 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_334 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_276 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_131_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_521 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_611 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_151_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_351 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_384 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_818 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_391 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_520 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_912 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_292 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_520 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_715 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_867 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_556 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_422 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_416 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_751 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_301 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_312 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_489 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_62 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_556 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_720 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_583 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_268 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_32 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_629 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_142 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_175 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_197 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_924 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_776 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_533 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_555 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_131_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_415 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_113_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_93 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_0_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_110_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_245 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_690 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_532 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_924 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_146_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_318 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_532 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_373 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_598 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_924 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_434 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_428 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_313 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_302 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_74 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_568 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_211 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_266 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_299 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_351 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_540 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_398 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_916 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_733 VGND VPWR sky130_fd_sc_hd__decap_12
X_09_ _09_/HI chany_bottom_out[8] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_80_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_147_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_143 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_176 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_332 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_198 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_314 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_562 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_144_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_317 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_306 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_501 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_545 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_567 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_394 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_861 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_574 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_544 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_739 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_605 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_830 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_105 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_330 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_739 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_249 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_385 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_446 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_720 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_77_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_842 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_303 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_812 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_507 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_105 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_300 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_867 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_552 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_764 VGND VPWR sky130_fd_sc_hd__decap_12
X_08_ _08_/HI chanx_right_out[0] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_26_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_263 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_100 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_133 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_672 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_111 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_166 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_199 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_745 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_579 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_830 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_154_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_362 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_590 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_310 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_343 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_501 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_556 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_898 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_403 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_842 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_629 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_33_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_361 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_342 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_898 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_62 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_745 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_276 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_304 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_684 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_879 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_745 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_776 VGND VPWR sky130_fd_sc_hd__decap_12
X_07_ _07_/HI chanx_right_out[1] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_26_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_249 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_916 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_134 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_684 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_101 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_520 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_189 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_757 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_818 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_727 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_374 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_617 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_154_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_635 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_94_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_149_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_373 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_598 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_568 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_415 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_629 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_51 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_62 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_196 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_263 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_146_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_296 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_373 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_220 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_367 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_513 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_398 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_916 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_459 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_696 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_251 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_96_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_305 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_236 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_310 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_696 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_324 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_521 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_757 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_788 VGND VPWR sky130_fd_sc_hd__decap_12
X_06_ _06_/HI chanx_right_out[2] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_80_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_257 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_124 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_471 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_113 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_157 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_696 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_179 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_306 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_769 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_373 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_276 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_320 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_367 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_812 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_385 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_794 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_916 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_253 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_154_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_385 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_672 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_867 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_714 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_769 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_257 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_267 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_39 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_306 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_204 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_900 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_300 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_483 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_202 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_550 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_769 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_05_ _05_/HI chanx_right_out[3] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_93_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_196 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_119_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_218 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_269 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_125 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_103 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_158 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_483 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_169 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_623 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_351 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_156_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_910 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_505 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_571 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_910 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_280 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_812 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_239 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_924 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_300 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_837 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ ccff_tail mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset
+ clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_272 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_232 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_367 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_879 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_507 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_726 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_757 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_33_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_684 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_307 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_507 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_249 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_912 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_62 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_337 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_562 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_271 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_245 VGND VPWR sky130_fd_sc_hd__decap_12
X_04_ _04_/HI chanx_right_out[4] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_38_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_104 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_495 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_159 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_568 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_501 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_342 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_397 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_105 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_583 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_690 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_347 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_292 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_825 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_398 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_251 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_593 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_86 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_696 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_324 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_738 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_243 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_276 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_156_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_318 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_308 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_708 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_134_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_145_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_202 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_75_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_739 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_806 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_379 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_349 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_215 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_440 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_257 VGND VPWR sky130_fd_sc_hd__decap_12
X_03_ _03_/HI chanx_right_out[5] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_80_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_80 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_34_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_349 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_446 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_806 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_105 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_116 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_149 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_86 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_471 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_794 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_861 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_708 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_39 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_130_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_452 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_53_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_540 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_354 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_837 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_720 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_267 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_483 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_611 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_483 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_309 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_207 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_145_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_623 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_818 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_86 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_391 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_227 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_513 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_715 VGND VPWR sky130_fd_sc_hd__decap_12
X_02_ _02_/HI chanx_right_out[6] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_76_93 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_65_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_483 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_105 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_111_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_106 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_139 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_117 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_328 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_910 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_464 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_311 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_800 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_366 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_343 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_148_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_910 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_552 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_924 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_489 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_879 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_849 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_916 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_27 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_136_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_297 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_337 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_707 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_623 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_267 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_635 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_60_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_239 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_464 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_151_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_727 VGND VPWR sky130_fd_sc_hd__decap_12
X_01_ _01_/HI chanx_right_out[7] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_81_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_635 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_107 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_605 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_118 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_146_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_922 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_476 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_812 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_323 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_537 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_507 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_355 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_509 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_800 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_94_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_51 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_849 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_306 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_788 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_290 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_666 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_265 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_123 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_145_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_379 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_349 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_410 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_272 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_250 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_142_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_794 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_422 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_647 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_861 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_708 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_231 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_00_ _00_/HI chanx_right_out[8] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_93_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_108 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_263 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_105 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_335 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_521 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_550 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_403 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_654 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_379 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_318 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_611 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_127_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_296 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_291 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_280 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_145_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_550 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_520 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_259 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_154_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_873 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_391 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_361 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_403 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_116_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_910 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_306 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_339 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_659 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_873 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_501 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_528 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_720 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_489 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_764 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_776 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_109 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_714 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_769 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_331 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_550 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_837 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_156_881 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_415 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_666 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_910 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_270 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_245 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_292 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_281 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_532 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_245 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_132_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_249 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_727 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_271 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_830 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_727 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_93_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_690 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_446 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_513 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_800 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_90 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_220 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_726 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_800 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_304 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_303 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_220 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_347 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_398 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_93_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_893 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_788 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_678 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_331 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_397 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_276 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_260 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_257 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_293 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_282 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_271 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_202 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_257 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_268 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_155_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_861 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_842 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_105 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_330 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_886 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_672 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_267 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_812 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_80 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_91 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_171 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_738 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_745 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_812 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_171 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_300 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_87_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_672 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_850 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_745 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_586 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_351 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_261 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_250 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_294 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_283 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_251 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_873 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_501 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_149_720 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_148_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_254 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_232 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_154_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_342 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_102_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_489 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_459 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_898 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_509 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_550 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_403 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_141 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_120_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_415 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_70 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_916 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_910 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_757 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_391 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_306 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_654 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_862 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_367 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_84_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_148_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_146_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_74 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_598 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_654 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_125 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_757 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_97_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_311 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_322 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_366 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_251 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_240 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_295 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_284 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_273 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_262 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_263 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_446 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_156_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_354 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_332 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_60 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_93 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_707 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_769 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_825 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_335 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_306 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_318 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_532 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_394 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_276 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_257 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_666 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_739 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_252 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_241 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_230 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_285 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_274 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_263 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_924 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_296 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_490 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_855 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_143_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_525 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_171 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_139_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_39 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_288 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_171 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_300 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_428 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_867 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_837 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_94 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_303 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_347 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_318 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_831 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_544 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_362 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_391 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_92_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_288 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_269 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_483 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_678 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_605 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_149 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_330 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_343 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_818 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_59_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_683 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_910 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_330 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_147_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_32 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_150_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_898 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_242 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_231 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_220 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_781 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_286 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_275 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_264 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_253 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_297 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_276 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_268 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_574 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_757 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_684 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_62 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_654 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_84 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_715 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_260 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_440 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_849 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_501 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_359 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_495 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_556 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_374 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_239 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_142_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_528 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_513 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_44_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_495 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_106 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_355 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_629 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_695 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_74 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_210 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_568 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_243 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_232 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_221 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_410 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_276 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_265 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_254 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_51 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_298 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_287 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_196 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_881 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_129 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_324 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_149_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_453 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_280 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_825 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_611 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_830 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_59_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_257 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_471 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_666 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_85 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_202 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_92_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_154 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_452 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_861 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_800 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_739 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_629 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_293 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_794 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_652 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_304 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_326 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_385 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_200 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_233 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_222 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_211 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_794 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_277 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_266 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_255 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_244 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_764 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_299 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_288 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_893 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_271 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_68 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_267 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_910 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_483 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_86 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_75 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_678 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_86 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_739 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_155_525 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_239 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_483 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_306 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_394 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_321 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_781 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_910 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_924 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_434 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_664 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_867 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_342 VGND VPWR sky130_fd_sc_hd__decap_12
X_17_ _17_/HI chany_bottom_out[0] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_80_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_489 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_146_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_201 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_98 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_234 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_223 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_212 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_581 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_267 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_256 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_245 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_434 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_289 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_278 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_850 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_507 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_603 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_280 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_238 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_433 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_293 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_271 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_219 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_922 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_304 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_337 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_495 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_98 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_537 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_281 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_922 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_476 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_410 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_605 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_830 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_362 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_281 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_33_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_509 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_410 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_605 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_347 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_154_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_251 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_446 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_621 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_312 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_879 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_676 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_800 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_354 VGND VPWR sky130_fd_sc_hd__decap_12
X_16_ _16_/HI chany_bottom_out[1] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_38_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_339 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_68 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_224 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_213 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_202 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_251 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_268 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_257 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_246 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_235 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_593 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_279 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_862 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_324 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_90_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_276 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_276 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_298 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_154_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_292 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_445 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_398 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_349 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_66 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_88 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_544 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_98 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_151_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_264 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_253 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_331 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_293 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_135 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_886 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_133_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_794 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_647 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_842 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_869 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_374 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_276 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_764 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_825 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_263 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_633 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_324 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_141 VGND VPWR sky130_fd_sc_hd__decap_12
X_15_ _15_/HI chany_bottom_out[2] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_769 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_69_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_225 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_214 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_203 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_263 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_258 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_247 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_236 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_269 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_296 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_611 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_288 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_806 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_259 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_330 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_457 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_490 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_818 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_328 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_56 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_67 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_89 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_361 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_910 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_343 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_489 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_434 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_320 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_720 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_117 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_77_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_581 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_220 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_629 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_837 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_916 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_489 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_459 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_645 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_550 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_269 VGND VPWR sky130_fd_sc_hd__decap_12
X_14_ _14_/HI chany_bottom_out[3] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_65_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_142_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_319 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_849 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_215 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_204 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_916 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_259 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_248 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_237 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_226 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_831 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_623 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_818 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_497 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_306 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_135_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_149 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_267 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_683 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_261 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_469 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_285 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_410 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_605 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_830 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_57 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_924 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_211 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_300 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_340 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_251 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_446 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_838 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_507 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_398 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_123_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_593 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_788 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_849 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_306 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_98 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_602 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_337 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_623 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_394 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_13_ _13_/HI chany_bottom_out[4] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_92_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_216 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_205 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_249 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_238 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_227 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_574 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_635 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_910 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_106 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_695 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_903 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_273 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_272 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_154 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_886 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_145_733 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_422 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_842 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_58 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_289 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_733 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_142_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_263 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_105 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_391 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_318 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_745 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_288 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_806 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_614 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_349 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_362 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_837 VGND VPWR sky130_fd_sc_hd__decap_12
X_12_ _12_/HI chany_bottom_out[5] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_77_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_520 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_206 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_745 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_239 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_228 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_217 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_800 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_922 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_647 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_466 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_652 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_873 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_230 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_251 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_489 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_556 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_50_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_276 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_776 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_629 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_59 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_257 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_489 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_459 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_301 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_807 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_312 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_306 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_316 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_562 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_245 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_532 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_757 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_818 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_374 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_751 VGND VPWR sky130_fd_sc_hd__decap_12
X_11_ _11_/HI chany_bottom_out[6] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_38_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_562 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_207 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_532 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_229 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_218 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_267 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_373 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_598 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_440 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_659 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_478 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_629 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_117 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_115_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_664 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_513 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_242 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_764 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_263 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_144_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_568 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_146_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_513 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_1_428 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_916 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_236 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_347 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_280 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_276 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_819 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_318 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_184 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_77_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_350 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_142_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_574 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_544 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_769 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_611 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_830 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_666 VGND VPWR sky130_fd_sc_hd__decap_12
X_10_ _10_/HI chany_bottom_out[7] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_93_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_544 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_219 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_208 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_257 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_385 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_227 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_435 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_452 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_886 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_3_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_61_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_621 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_676 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_886 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_220 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_297 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_267 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_289 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_171 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_105 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_672 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_204 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_311 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_359 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_292 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_288 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_483 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_739 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_117_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_483 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_586 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_428 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_556 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_623 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_842 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_623 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_57_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_586 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_209 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_869 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_873 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_910 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_239 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_105 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_464 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_447 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_330 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_147 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_48_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_280 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_633 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_898 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_156_211 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_272 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_261 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_254 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_757 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_581 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_245 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_459 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_312 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_249 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_367 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_57_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_849 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_306 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_924 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_591 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_373 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_598 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_440 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_501 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_300 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_513 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_708 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_398 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_281 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_404 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_117 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_62 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_459 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_51 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_80 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_34_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_292 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_147_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_916 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_645 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_696 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_415 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_497 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_321 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_520 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_291 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_276 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_696 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_143_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_769 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_306 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_339 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_261 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_257 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_17_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_666 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_190 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_394 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_922 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_769 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_611 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_830 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_316 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_305 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_342 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_154_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_227 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_452 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_513 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_838 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_867 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_416 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_293 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_155_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_794 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_602 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_764 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_245 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_288 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_154 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_2_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_121_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_68 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_837 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_207 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_143_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_910 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_678 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_191 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_362 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_166 VGND VPWR sky130_fd_sc_hd__decap_12
.ends
