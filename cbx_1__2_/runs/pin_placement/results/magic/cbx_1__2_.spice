* NGSPICE file created from cbx_1__2_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

.subckt cbx_1__2_ chanx_out_8_ top_grid_pin_0_ pReset chanx_out_16_ top_grid_pin_12_
+ chanx_in_5_ chanx_in_1_ top_grid_pin_8_ chanx_out_10_ chanx_in_10_ chanx_out_3_
+ prog_clk bottom_grid_pin_8_ ccff_tail top_grid_pin_14_ chanx_out_0_ chanx_out_13_
+ chanx_out_12_ chanx_out_9_ chanx_in_16_ chanx_out_15_ top_grid_pin_2_ chanx_in_4_
+ chanx_out_17_ top_grid_pin_10_ chanx_in_13_ top_grid_pin_6_ bottom_grid_pin_0_ chanx_in_8_
+ ccff_head chanx_in_9_ chanx_out_1_ chanx_in_6_ chanx_in_12_ chanx_out_11_ chanx_in_15_
+ chanx_in_17_ bottom_grid_pin_4_ chanx_in_3_ chanx_in_7_ chanx_in_11_ chanx_out_14_
+ chanx_out_2_ chanx_in_0_ chanx_out_5_ chanx_out_6_ top_grid_pin_4_ chanx_in_2_ chanx_in_14_
+ chanx_out_7_ chanx_out_4_
XFILLER_22_166 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
Xmem_top_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X _18_/VGND _18_/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_bottom_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_98 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_32 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_184 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_42 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_bottom_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset clkbuf_3_2_0_prog_clk/X
+ _16_/VGND _20_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_154 _04_/VGND _04_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_11 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_2_1_0_prog_clk/A _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_4_0_prog_clk clkbuf_2_2_0_prog_clk/X clkbuf_3_4_0_prog_clk/X PHY_23/VGND
+ PHY_21/VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_top_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_7 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_97 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_52 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_150 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_32 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_top_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_3 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_23 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_53 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_175 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_120 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_87 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XPHY_170 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_123 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_112 _01_/VGND _09_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_178 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_123 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_101 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_127 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_11 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_115 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ _01_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_196 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_54 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_32 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_21 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _03_/VGND _04_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ _03_/VGND _04_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_44 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_90 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ _01_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _08_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_184 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_110 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_55 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_11 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XPHY_171 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_135 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_98 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XPHY_160 _08_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_154 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_99 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_190 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_102 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_32 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_21 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_113 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_1
Xmem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_190 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_47 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_58 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_56 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_131 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ _09_/VGND _09_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_145 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_3 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_44 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_108 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_10 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_56 _22_/VGND _22_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_12 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_87 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_130 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_36 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_196 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_166 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XPHY_172 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_147 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XPHY_161 _01_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_150 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_136 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_1_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_3_3_0_prog_clk/A _16_/VGND PHY_45/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_26_66 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_44 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_180 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_15 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_143 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_91 _19_/VGND _19_/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_67 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_34 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA__12__A chanx_in_10_ PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_124 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_27 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_3 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_14 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_47 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_201 _22_/VGND _22_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_56 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_24 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_55 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_44 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_142 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_3_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_3_0_prog_clk/X _16_/VGND _20_/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_6_15 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_26 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_48 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_175 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_131 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_120 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_90 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_123 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_4
XANTENNA__20__A chanx_in_1_ _16_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XPHY_173 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_159 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XPHY_162 _01_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_151 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_140 _16_/VGND _20_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_178 _14_/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_3 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_78 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_56 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_148 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_148 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_27 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__15__A chanx_in_13_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_36 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_25 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_152 _27_/VGND _27_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_155 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
Xmem_top_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X _08_/VGND _18_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_136 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_4
Xmem_bottom_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X _04_/VGND _04_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_59 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X _20_/VGND _20_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_24 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_6
XANTENNA__23__A chanx_in_4_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
X_28_ chanx_in_9_ chanx_out_9_ _04_/VGND _04_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_28_154 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__18__A chanx_in_16_ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_143 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XPHY_174 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_116 _01_/VGND _09_/VPWR sky130_fd_sc_hd__fill_2
XPHY_163 _01_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_152 _18_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_141 _16_/VGND _20_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_130 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_160 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_116 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_105 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _12_/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_39 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_59 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_119 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XANTENNA__26__A chanx_in_7_ _03_/VGND _04_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_112 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_123 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_167 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_93 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_181 _03_/VGND _04_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_3_0_prog_clk_A clkbuf_3_3_0_prog_clk/A _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_3 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
X_27_ chanx_in_8_ chanx_out_8_ _27_/VGND _27_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_29_35 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_166 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_59 _22_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_155 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_9 _22_/VGND _22_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_180 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_59 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_15 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XPHY_175 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_164 _01_/VGND _09_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_153 _18_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_142 _16_/VGND _20_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_131 _22_/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_120 _14_/VGND _14_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_128 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XPHY_0 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_3
Xmem_bottom_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X _08_/VGND _07_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_21_172 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_80 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_150 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_154 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_16 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_0_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_0_0_prog_clk/X _12_/VGND PHY_26/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ _04_/VGND _04_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_179 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ _14_/VGND _14_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_83 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ _16_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_15 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_6
Xmem_bottom_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X _09_/VGND _09_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_3 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_80 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
X_26_ chanx_in_7_ chanx_out_7_ _04_/VGND _04_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_62 _03_/VGND _04_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_51 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_178 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_167 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_123 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_93 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
X_09_ _09_/HI top_grid_pin_2_ _09_/VGND _09_/VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__diode_2
XPHY_165 _01_/VGND _09_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_37 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XPHY_154 _18_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_143 _20_/VGND _20_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_132 _22_/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_121 _14_/VGND _14_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_110 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_151 _01_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ _12_/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XPHY_1 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_15 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_2_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_2_0_prog_clk/X _20_/VGND _20_/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_184 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_94 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_144 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_166 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_38 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_18 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_7 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_93 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_1
X_25_ chanx_in_6_ chanx_out_6_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ _27_/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_59 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_48 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_4
X_08_ _08_/HI top_grid_pin_14_ _08_/VGND _07_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_27_190 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_179 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_3_0_prog_clk/A _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_49 _01_/VGND _09_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_127 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_116 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_190 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_105 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XPHY_100 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 _01_/VGND _09_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_155 _08_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_144 _20_/VGND _20_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_133 _22_/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_122 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_171 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XPHY_111 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_196 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_62 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_93 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_60 _14_/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_178 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_29 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_104 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_6
Xmem_bottom_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_30 _19_/VGND _19_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_28 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_184 _03_/VGND _04_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_151 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_3
Xmem_bottom_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X _27_/VGND _27_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_93 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
X_24_ chanx_in_5_ chanx_out_5_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_73 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ _19_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_3 _09_/VGND _09_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_180 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_114 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_71 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_31_28 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_6
X_07_ _07_/HI top_grid_pin_12_ _01_/VGND _07_/VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ _27_/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XPHY_167 _09_/VGND _09_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_156 _08_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_150 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_3
XPHY_145 _20_/VGND _20_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_134 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XPHY_123 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_117 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XPHY_112 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_101 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_109 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_4
XPHY_3 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_120 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_142 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_93 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_116 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_127 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_75 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ _19_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_62 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_40 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_72 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_98 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_3
X_23_ chanx_in_4_ chanx_out_4_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_28_126 _08_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_85 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_63 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
X_06_ _06_/HI top_grid_pin_10_ _01_/VGND _07_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_25_3 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XPHY_168 _09_/VGND _09_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_157 _08_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_146 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_184 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
XPHY_135 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_62 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_51 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XPHY_124 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_129 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XPHY_113 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ _12_/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XPHY_102 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_154 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_184 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XPHY_4 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_53 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_29 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ _09_/VGND _09_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_154 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_110 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_1_0_prog_clk clkbuf_2_0_0_prog_clk/X clkbuf_3_1_0_prog_clk/X PHY_23/VGND
+ _12_/VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_4_32 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_96 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _16_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__dfrbp_1
X_22_ chanx_in_3_ chanx_out_3_ _22_/VGND _22_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_66 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
Xmem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X _01_/VGND _09_/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_160 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_127 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_62 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
X_05_ _05_/HI top_grid_pin_0_ _01_/VGND _07_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_3 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XPHY_169 _09_/VGND _09_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_158 _08_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_147 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_196 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_130 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XPHY_136 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_125 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_103 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_166 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ _12_/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XPHY_5 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_111 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ _22_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ _08_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ _14_/VGND _14_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_166 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_95 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_62 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_44 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_184 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_53 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_176 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_143 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_top_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_63 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_6
X_21_ chanx_in_2_ chanx_out_2_ _04_/VGND _04_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_78 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_194 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_172 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_85 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_98 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_21 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_32 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
X_04_ _04_/HI bottom_grid_pin_0_ _04_/VGND _04_/VPWR sky130_fd_sc_hd__conb_1
XPHY_159 _08_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_148 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_120 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XPHY_137 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_126 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_104 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_178 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_123 _01_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XPHY_6 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_11 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_66 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_3 _01_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_123 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_74 _09_/VGND _09_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_64 _14_/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_178 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_105 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_119 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_23 _19_/VGND _19_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_196 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_top_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_87 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_111 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_3 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X _16_/VGND _20_/VPWR sky130_fd_sc_hd__dfrbp_1
X_20_ chanx_in_1_ chanx_out_1_ _20_/VGND _20_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_28_118 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_20 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__clkbuf_16
Xmem_bottom_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_10_77 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_7 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_4
Xmem_top_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ ccff_tail mem_top_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset clkbuf_3_2_0_prog_clk/X
+ _01_/VGND _09_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_184 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
X_03_ _03_/HI bottom_grid_pin_4_ _03_/VGND _04_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_187 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XPHY_116 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_105 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_3_4_0_prog_clk_A clkbuf_2_2_0_prog_clk/X PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XPHY_149 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_154 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
XPHY_138 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_127 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_bottom_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_7 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_3 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ _08_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_32 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_21 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_113 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_117 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_42 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_31 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_11 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_189 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_156 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_123 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_98 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_76 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_32 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_21 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_0_0_prog_clk clkbuf_2_0_0_prog_clk/X clkbuf_3_0_0_prog_clk/X _12_/VGND _12_/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_199 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_152 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_1
X_02_ _02_/HI bottom_grid_pin_8_ _04_/VGND _04_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_24_166 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
XPHY_139 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_88 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_55 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_33 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XPHY_128 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_106 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_103 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_3 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_188 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_111 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_8
XPHY_8 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_24 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_57 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_top_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ _08_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_44 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_32 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ _22_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_180 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_184 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_87 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_54 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_154 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_45 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_168 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_135 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_59 _03_/VGND _04_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_15 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_120 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X _16_/VGND _20_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_19_55 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_57 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_156 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
X_01_ _01_/HI top_grid_pin_8_ _01_/VGND _09_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_24_178 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_134 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_45 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_4
XPHY_129 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_107 _12_/VGND _12_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_91 _04_/VGND _04_/VPWR sky130_fd_sc_hd__fill_1
Xmem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X _01_/VGND _07_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_15_123 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X _04_/VGND _19_/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_9 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_14 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_69 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_148 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_77 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_44 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_11 _09_/VGND _09_/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _01_/VGND _09_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_3_0_prog_clk/A _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_181 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_56 _14_/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_196 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_top_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _01_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_99 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_15 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_26 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_133 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_166 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_103 _03_/VGND _04_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_180 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_27 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__13__A chanx_in_11_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_3 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_89 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_67 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_45 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_25 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_69 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_168 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
X_00_ _00_/HI top_grid_pin_6_ _01_/VGND _09_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_18_154 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_190 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_124 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_102 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
XPHY_119 _14_/VGND _14_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_108 _12_/VGND _12_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_127 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_7 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_190 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_135 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_90 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_116 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_190 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _27_/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_89 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_56 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_193 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_68 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__21__A chanx_in_2_ _03_/VGND _04_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_3 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_160 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_120 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_131 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_34 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA__16__A chanx_in_14_ _16_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_145 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_178 _19_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_70 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_57 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_0_prog_clk_A prog_clk _14_/VGND _14_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X _18_/VGND _18_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_39 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_15 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_125 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_166 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__24__A chanx_in_5_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XPHY_109 _12_/VGND _12_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_bottom_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X _12_/VGND _12_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_93 _04_/VGND _04_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_139 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_147 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__19__A chanx_in_17_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_68 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_150 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_117 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_3 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_172 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_8
Xmem_bottom_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_143 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_15 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_190 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_59 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA__27__A chanx_in_8_ PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_69 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_123 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_137 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_178 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XPHY_90 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_181 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_59 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_159 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_107 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_28 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_15 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_184 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_155 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_93 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_49 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_90 _08_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_81 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_91 _01_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_59 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_15 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_3 _19_/VGND _19_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_149 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_190 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ _16_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_62 _04_/VGND _04_/VPWR sky130_fd_sc_hd__fill_1
XPHY_80 _04_/VGND _19_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_91 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_138 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_116 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ _14_/VGND _14_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ _27_/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_15 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_174 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_196 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_123 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_167 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_59 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_15 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_17_92 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_170 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_181 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_107 _03_/VGND _04_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_62 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_0_0_prog_clk_A clkbuf_2_0_0_prog_clk/X _12_/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_93 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_103 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_106 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_136 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XPHY_70 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_81 _04_/VGND _19_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_92 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_194 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_150 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_50 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_27 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_142 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_93 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_120 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_179 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_40 _27_/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_38 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_27 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_3_5_0_prog_clk_A clkbuf_2_2_0_prog_clk/X PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_105 _19_/VGND _19_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_190 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_73 _27_/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_3 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_119 _03_/VGND _04_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_28 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_17 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_93 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_148 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_115 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_118 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XPHY_60 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_60 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_148 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_4
XPHY_71 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_82 _04_/VGND _19_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_93 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_97 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_184 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_162 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_62 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_154 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_29 _14_/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_8 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ _03_/VGND _04_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_30 _27_/VGND _27_/VPWR sky130_fd_sc_hd__fill_1
Xmem_top_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_top_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X _08_/VGND _18_/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_bottom_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X _19_/VGND _19_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_194 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_93 _08_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_75 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_83 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_72 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_61 _01_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XPHY_61 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XPHY_50 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_3
XPHY_72 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_83 _19_/VGND _19_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_94 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_171 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_32 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_174 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_119 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_3 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_166 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_84 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_62 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_51 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_94 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_151 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_162 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_184 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_187 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_180 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XPHY_62 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_3
XPHY_51 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_62 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XPHY_40 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_44 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XPHY_73 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_84 _19_/VGND _19_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_95 _27_/VGND _27_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_42 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_3 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_41 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_123 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_127 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_32 _27_/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_65 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_108 _19_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
X_19_ chanx_in_17_ chanx_out_17_ _19_/VGND _19_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_17_96 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X _12_/VGND _12_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_174 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_4
Xmem_top_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_top_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X _08_/VGND _07_/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_199 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_22 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_55 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_66 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_3 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XPHY_63 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_3
XPHY_52 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_74 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XPHY_41 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XPHY_30 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_67 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_56 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_6
XPHY_74 _03_/VGND _04_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_85 _19_/VGND _19_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_96 _27_/VGND _27_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_154 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_184 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_121 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_154 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ _01_/VGND _09_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ _01_/VGND _09_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_102 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_106 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_190 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_11 _27_/VGND _27_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_22 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_77 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
X_18_ chanx_in_16_ chanx_out_16_ _18_/VGND _18_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_33_63 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_86 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_42 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_63 _08_/VGND _18_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_65 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_32 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_160 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XPHY_64 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ _01_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XPHY_53 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_86 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_42 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XPHY_42 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XPHY_31 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_3
XPHY_75 _03_/VGND _04_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_86 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_97 _27_/VGND _27_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_20 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_166 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_133 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_196 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_79 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_66 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_55 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_166 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_114 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_32 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_3 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
X_17_ chanx_in_15_ chanx_out_15_ _04_/VGND _04_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_6_140 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_89 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_75 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_top_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_121 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_143 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_8
Xmem_top_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_top_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X _08_/VGND _07_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_168 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_79 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_30_65 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_32 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_172 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_8
Xmem_bottom_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_65 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_3
XPHY_54 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_98 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_54 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_6
XPHY_43 _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_109 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_4
XPHY_32 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_3
XPHY_21 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XPHY_76 _03_/VGND _04_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_10 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XPHY_87 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_178 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_145 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_178 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_123 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_178 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_top_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _01_/VGND _09_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_99 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_11 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_148 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_3 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
X_16_ chanx_in_14_ chanx_out_14_ _16_/VGND _20_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_6_152 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_87 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_32 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_55 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_133 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_32 _08_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_21 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_47 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_99 _01_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_77 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_11 _01_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_184 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_7_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_7_0_prog_clk/X _16_/VGND _20_/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_14_89 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XPHY_66 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_3
XPHY_55 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_154 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_121 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XPHY_44 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XPHY_33 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_3
XPHY_22 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_3
XPHY_77 _04_/VGND _04_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_88 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_11 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XPHY_99 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_15 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_113 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_1_0_prog_clk_A clkbuf_2_0_0_prog_clk/X PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_13 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_190 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_45 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_105 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA__11__A chanx_in_0_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_3 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
X_15_ chanx_in_13_ chanx_out_13_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_8_36 _27_/VGND _27_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_44 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_123 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_178 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_66 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_11 _08_/VGND _18_/VPWR sky130_fd_sc_hd__fill_1
Xmem_bottom_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_4_0_prog_clk/X PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_137 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_15 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_3_6_0_prog_clk_A clkbuf_3_7_0_prog_clk/A _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_59 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_57 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_6
Xmem_bottom_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_29_196 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_6
XPHY_12 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XPHY_67 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_3
XPHY_56 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XPHY_45 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_111 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_100 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_8
XPHY_34 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XANTENNA__14__A chanx_in_12_ PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__diode_2
XPHY_23 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__decap_3
XPHY_78 _04_/VGND _04_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_27 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_4
XPHY_89 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_125 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_117 _22_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_180 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_184 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_70 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_154 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_13 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
X_14_ chanx_in_12_ chanx_out_12_ _14_/VGND _14_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_56 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XANTENNA__22__A chanx_in_3_ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ _12_/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_113 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_3 _01_/VGND _09_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_78 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__17__A chanx_in_15_ _03_/VGND _04_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_149 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_69 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_120 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XPHY_57 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_178 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_145 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_8
XPHY_46 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_3
XPHY_35 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XPHY_24 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_3
XPHY_79 _04_/VGND _04_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_68 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_13 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_123 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_137 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_59 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA__25__A chanx_in_6_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_107 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_2_1_0_prog_clk/A _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_196 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_166 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_16 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_7 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
X_13_ chanx_in_11_ chanx_out_11_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_17_47 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_158 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_3 _20_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_57 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_106 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_90 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_15 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA__28__A chanx_in_9_ _03_/VGND _04_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ _22_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X _19_/VGND _19_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_60 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_93 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XPHY_58 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XPHY_47 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_3
XPHY_36 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XPHY_25 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_201 _03_/VGND _04_/VPWR sky130_fd_sc_hd__fill_1
XPHY_69 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_14 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_105 _09_/VGND _09_/VPWR sky130_fd_sc_hd__decap_4
Xmem_bottom_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_2_0_prog_clk/X PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_17_135 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_171 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_6_0_prog_clk clkbuf_3_7_0_prog_clk/A clkbuf_3_6_0_prog_clk/X _20_/VGND _20_/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_23_105 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ _22_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_149 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_90 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_160 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_50 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_120 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_131 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_59 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_15 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_152 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_1
X_12_ chanx_in_10_ chanx_out_10_ _12_/VGND _12_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_178 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_59 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_200 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_14 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_3 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_15 _01_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_100 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XPHY_59 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XPHY_48 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_3
XPHY_37 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XPHY_26 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XPHY_15 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_147 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_117 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_17 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_172 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_62 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_84 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_110 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_143 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_27 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_109 PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_93 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ _12_/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
X_11_ chanx_in_0_ chanx_out_0_ _04_/VGND _19_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_160 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_171 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_19 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_123 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_3_0_prog_clk/A _14_/VGND PHY_37/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_93 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ _19_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XPHY_49 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_3
XPHY_38 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XPHY_27 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
Xmem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_84 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_8
XPHY_16 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_159 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_115 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ _27_/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_184 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_70 _01_/VGND _09_/VPWR sky130_fd_sc_hd__fill_1
Xmem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_1_0_prog_clk/X _27_/VGND _27_/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_6_0_prog_clk/X _01_/VGND _07_/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_3 PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_184 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_74 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_155 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
X_10_ _10_/HI top_grid_pin_4_ _08_/VGND _18_/VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_154 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_110 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_17 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_117 _04_/VGND _19_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_139 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_93 _16_/VGND _20_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_60 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_3_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_3_7_0_prog_clk/A _22_/VGND PHY_45/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_183 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_194 _04_/VGND _04_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_62 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_93 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_82 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_3 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_190 _08_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_105 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_17 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XPHY_28 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_30 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XPHY_17 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_3
XPHY_39 PHY_39/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_196 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_152 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_119 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ _12_/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_93 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_196 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_123 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_167 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_84 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_40 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_5_0_prog_clk clkbuf_2_2_0_prog_clk/X clkbuf_3_5_0_prog_clk/X PHY_23/VGND
+ _12_/VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_10_166 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_144 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_129 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_7 _20_/VGND _20_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_140 _04_/VGND _04_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_74 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_top_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ _01_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_3 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_19 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_7_0_prog_clk/X _22_/VGND _22_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_84 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_117 _18_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_4
XPHY_29 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XPHY_18 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_109 _09_/VGND _09_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_62 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_40 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _04_/VGND _19_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_120 _01_/VGND _09_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_5_0_prog_clk/X PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_120 _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_54 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_190 _27_/VGND _27_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_179 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
Xmem_bottom_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_0_0_prog_clk/X _12_/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_52 _12_/VGND _12_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_178 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_105 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_3_2_0_prog_clk_A clkbuf_3_3_0_prog_clk/A _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_62 _16_/VGND _20_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_29 _08_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_86 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_19 _01_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_148 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_104 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_30 _22_/VGND _22_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_32 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XPHY_19 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_73 _01_/VGND _09_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_62 _01_/VGND _09_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_184 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_151 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_3_7_0_prog_clk_A clkbuf_3_7_0_prog_clk/A _20_/VGND _20_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_52 PHY_31/VGND _14_/VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_1_0_prog_clk/A _14_/VGND PHY_37/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_16_184 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_154 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_132 _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_88 _04_/VGND _19_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_20 _12_/VGND _12_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_3 _19_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_19 _09_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56 _03_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_43 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_98 _27_/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _16_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_30 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_116 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_93/VGND _27_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_95 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_62 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_40 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_20 _22_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_2_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_2_0_prog_clk/X _12_/VGND PHY_26/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_3 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND _12_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_44 PHY_93/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_196 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_163 _20_/VGND PHY_53/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _22_/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_3_3_0_prog_clk/X _22_/VGND _22_/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ _22_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_119 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_108 _14_/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_196 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_141 _14_/VGND _14_/VPWR sky130_fd_sc_hd__decap_12
.ends
