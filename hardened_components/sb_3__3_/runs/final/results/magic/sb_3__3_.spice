* NGSPICE file created from sb_3__3_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__ebufn_1 abstract view
.subckt sky130_fd_sc_hd__ebufn_1 A TE_B Z VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A Y VGND VPWR
.ends

.subckt sb_3__3_ bottom_left_grid_pin_13_ bottom_right_grid_pin_11_ bottom_right_grid_pin_13_
+ bottom_right_grid_pin_15_ bottom_right_grid_pin_1_ bottom_right_grid_pin_3_ bottom_right_grid_pin_5_
+ bottom_right_grid_pin_7_ bottom_right_grid_pin_9_ ccff_head ccff_tail chanx_left_in[0]
+ chanx_left_in[1] chanx_left_in[2] chanx_left_in[3] chanx_left_in[4] chanx_left_in[5]
+ chanx_left_in[6] chanx_left_in[7] chanx_left_in[8] chanx_left_out[0] chanx_left_out[1]
+ chanx_left_out[2] chanx_left_out[3] chanx_left_out[4] chanx_left_out[5] chanx_left_out[6]
+ chanx_left_out[7] chanx_left_out[8] chany_bottom_in[0] chany_bottom_in[1] chany_bottom_in[2]
+ chany_bottom_in[3] chany_bottom_in[4] chany_bottom_in[5] chany_bottom_in[6] chany_bottom_in[7]
+ chany_bottom_in[8] chany_bottom_out[0] chany_bottom_out[1] chany_bottom_out[2] chany_bottom_out[3]
+ chany_bottom_out[4] chany_bottom_out[5] chany_bottom_out[6] chany_bottom_out[7]
+ chany_bottom_out[8] left_bottom_grid_pin_12_ left_top_grid_pin_11_ left_top_grid_pin_13_
+ left_top_grid_pin_15_ left_top_grid_pin_1_ left_top_grid_pin_3_ left_top_grid_pin_5_
+ left_top_grid_pin_7_ left_top_grid_pin_9_ pReset prog_clk VPWR VGND
XFILLER_22_122 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_26_63 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_148 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_137 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_126 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _26_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_23_53 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_132 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_22 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _54_/A VGND VPWR sky130_fd_sc_hd__inv_1
X_49_ _49_/A chany_bottom_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_18_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_45 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_120 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_54 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_43 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_131 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_120 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_75 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_35 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_1_ mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_12_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_10 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_23_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_65 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_2_144 VGND VPWR sky130_fd_sc_hd__decap_8
X_48_ _48_/A chany_bottom_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_6_24 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_21 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[0] mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_12_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_131 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_142 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_153 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__decap_4
X_47_ _47_/A chany_bottom_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_88 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_8 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_89 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_12 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_36 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_3_ mux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_13_ mux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_25_155 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_89 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_12 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_22_125 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_1_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_107 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _31_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_79 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_46_ _46_/A chanx_left_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _21_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
X_29_ _29_/HI _29_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_70 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_35 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _40_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_123 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_left_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _20_/HI mux_left_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_104 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_148 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_137 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_126 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_129 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_118 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_107 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _25_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_57 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _43_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_46 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_35 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
X_45_ _45_/A chanx_left_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_28_ _28_/HI _28_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_47 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[4] mux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_6_16 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_58 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_116 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _29_/HI mux_bottom_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_7_70 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _28_/HI mux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_26_46 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_35 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_13 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_39 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_59 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_15 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_9_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_69 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_44_ _44_/A chanx_left_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[7] mux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_27_ _27_/HI _27_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_83 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ ccff_tail mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N _19_/Y
+ clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_111 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_147 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_58 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_18 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_27 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_0_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__42__A _42_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_102 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_157 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_26 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_72 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_105 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_116 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_138 VGND VPWR sky130_fd_sc_hd__fill_2
X_43_ _43_/A chanx_left_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_18_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_16 VGND VPWR sky130_fd_sc_hd__fill_2
X_26_ _26_/HI _26_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _36_/HI mux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_7_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__50__A _50_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__45__A _45_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_92 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_50 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_140 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_bottom_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _30_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_bottom_grid_pin_12_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_40 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_84 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__53__A _53_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_150 VGND VPWR sky130_fd_sc_hd__decap_8
X_42_ _42_/A chanx_left_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _20_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__48__A _48_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_25_ _25_/HI _25_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_41 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_146 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_138 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_39 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_119 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _55_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[2] mux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_12_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_101 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_112 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_134 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_145 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _26_/HI mux_left_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_9 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _24_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_41_ _41_/A chanx_left_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_39 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_24_71 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _47_/A VGND VPWR sky130_fd_sc_hd__inv_1
X_24_ _24_/HI _24_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_40 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[2] mux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[7] mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_17 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_74 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_138 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_149 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_73 VGND VPWR sky130_fd_sc_hd__fill_2
X_40_ _40_/A chanx_left_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_left_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_18_18 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_24_83 VGND VPWR sky130_fd_sc_hd__decap_3
X_23_ _23_/HI _23_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_19_115 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_96 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_62 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_31 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_86 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_29 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_51 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_40 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_154 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_41 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_30 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_40 VGND VPWR sky130_fd_sc_hd__decap_8
X_22_ _22_/HI _22_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _36_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_51 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_108 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N _19_/Y clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_96 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_152 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_141 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_130 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_43 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_111 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_12_100 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _29_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_118 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _41_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_13_53 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_110 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_13_ mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_21_ _21_/HI _21_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _44_/A VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[0] mux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_left_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[5] mux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_4_56 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _37_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_75 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_20_ _20_/HI _20_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_107 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XANTENNA_mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_151 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_7_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_154 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_146 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_left_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _21_/HI mux_left_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_134 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_21 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_89 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_122 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_66 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _51_/A VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_103 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_111 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_7_ mux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_88 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_5_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _30_/HI mux_bottom_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _33_/HI mux_bottom_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_5_90 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_24_88 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_15 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_bottom_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _35_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_55 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_131 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_120 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_15_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_13_ mux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_45 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_34 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_91 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_47 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_58 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_115 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_23 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_12 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_130 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_141 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_103 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_12 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_9_ mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_19_89 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_143 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_57 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_left_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _37_/HI mux_left_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_7_26 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_6 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _48_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_16_57 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_153 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_101 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_70 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_13 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_125 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__19__A pReset VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_90 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_4_113 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_135 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_3_ mux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_13_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_138 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _27_/HI mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_14_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__40__A _40_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_137 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_148 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_137 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_126 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_115 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_104 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_107 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_129 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_118 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_107 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_147 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__43__A _43_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__38__A _38_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_bottom_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _34_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_3 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_40 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_24_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_116 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_38 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__51__A _51_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_141 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_5_ mux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__46__A _46_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_15_ mux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_11_152 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_141 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_130 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_7_145 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_107 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _45_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_24_16 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__54__A _54_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_7 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_70 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__49__A _49_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_70 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_50 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_150 VGND VPWR sky130_fd_sc_hd__decap_3
X_39_ _39_/A chanx_left_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_82 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_7 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_7_102 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_157 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_40 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_5_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_5_52 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_72 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_17 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_60 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_60 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_71 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_64 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_75 VGND VPWR sky130_fd_sc_hd__decap_12
X_55_ _55_/A chany_bottom_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_97 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[5] mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_20_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_18 VGND VPWR sky130_fd_sc_hd__fill_2
X_38_ _38_/A chanx_left_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_22_50 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _52_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_20 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_86 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_116 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_3_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_61 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_72 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[8] mux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_54_ _54_/A chany_bottom_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_85 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_122 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_37_ _37_/HI _37_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_126 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_137 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_1_ mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_11_ mux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_32 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_63 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _22_/HI mux_left_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _33_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_62 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_62 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_53_ _53_/A chany_bottom_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_73 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_31 VGND VPWR sky130_fd_sc_hd__decap_4
X_36_ _36_/HI _36_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_7_149 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_19_ pReset _19_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA_mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_133 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _49_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _31_/HI mux_bottom_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_96 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_52 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_41 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_56 VGND VPWR sky130_fd_sc_hd__decap_8
X_52_ _52_/A chany_bottom_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_63 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_bottom_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _34_/HI mux_bottom_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_54 VGND VPWR sky130_fd_sc_hd__decap_4
X_35_ _35_/HI _35_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_left_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_22 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_44 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_53 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[3] mux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_156 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_56 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_76 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _38_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_51_ _51_/A chany_bottom_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_34_ _34_/HI _34_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_bottom_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[3] mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_20_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_54 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_56 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[6] mux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_78 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _24_/HI mux_left_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_14_55 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_65 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_50_ _50_/A chany_bottom_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
X_33_ _33_/HI _33_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_left_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_88 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_148 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_137 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_126 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_68 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_66 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_133 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_144 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_91 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_147 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_36 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_23 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_66 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _28_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_23_146 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_113 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_35 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _46_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_20_116 VGND VPWR sky130_fd_sc_hd__decap_6
X_32_ _32_/HI _32_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_156 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_7 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[1] mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_67 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_bottom_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_3_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_58 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_31_ _31_/HI _31_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_22_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_35 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_13 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_6_154 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_102 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[1] mux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_71 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[6] mux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_9_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_16 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_156 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_68 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _53_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_20_129 VGND VPWR sky130_fd_sc_hd__decap_12
X_30_ _30_/HI _30_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_152 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_130 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_107 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_82 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_140 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_1_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_70 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_39 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_15 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_69 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_146 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_11_38 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__41__A _41_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_138 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_127 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_116 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_101 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_28 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_9_ mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_23_80 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_bottom_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_27 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__44__A _44_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_26 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__39__A _39_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_51 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _50_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_15_ mux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__52__A _52_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_18 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_127 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__47__A _47_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_52 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _23_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_137 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[8] mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_6_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_84 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[4] mux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__55__A _55_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_6 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_39 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_17 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _23_/HI mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _39_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_12_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_17 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _27_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_3_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_9_95 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_149 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_74 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _42_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_15_50 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_119 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_71 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_152 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_141 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_130 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _32_/HI mux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _35_/HI mux_bottom_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_3_118 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_50 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_19 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_5_ mux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_6_20 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_53 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_106 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_109 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_95 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_76 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_98 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_15_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_96 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_7 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_0_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_75 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_bottom_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_9_53 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_84 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_11_ mux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_20_85 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_32 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_118 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _25_/HI mux_left_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_17_118 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_22_154 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _32_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_9_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_103 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_22 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_55 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_117 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_75 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_64 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_9_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_128 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_139 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_7_ mux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_bottom_grid_pin_12_ mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_67 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_10 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_1_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_30 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _22_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xclkbuf_2_2_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
.ends
