* NGSPICE file created from sb_3__3_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__ebufn_1 abstract view
.subckt sky130_fd_sc_hd__ebufn_1 A TE_B Z VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A Y VGND VPWR
.ends

.subckt sb_3__3_ bottom_left_grid_pin_13_ bottom_right_grid_pin_11_ bottom_right_grid_pin_13_
+ bottom_right_grid_pin_15_ bottom_right_grid_pin_1_ bottom_right_grid_pin_3_ bottom_right_grid_pin_5_
+ bottom_right_grid_pin_7_ bottom_right_grid_pin_9_ ccff_head ccff_tail chanx_left_in[0]
+ chanx_left_in[1] chanx_left_in[2] chanx_left_in[3] chanx_left_in[4] chanx_left_in[5]
+ chanx_left_in[6] chanx_left_in[7] chanx_left_in[8] chanx_left_out[0] chanx_left_out[1]
+ chanx_left_out[2] chanx_left_out[3] chanx_left_out[4] chanx_left_out[5] chanx_left_out[6]
+ chanx_left_out[7] chanx_left_out[8] chany_bottom_in[0] chany_bottom_in[1] chany_bottom_in[2]
+ chany_bottom_in[3] chany_bottom_in[4] chany_bottom_in[5] chany_bottom_in[6] chany_bottom_in[7]
+ chany_bottom_in[8] chany_bottom_out[0] chany_bottom_out[1] chany_bottom_out[2] chany_bottom_out[3]
+ chany_bottom_out[4] chany_bottom_out[5] chany_bottom_out[6] chany_bottom_out[7]
+ chany_bottom_out[8] left_bottom_grid_pin_12_ left_top_grid_pin_11_ left_top_grid_pin_13_
+ left_top_grid_pin_15_ left_top_grid_pin_1_ left_top_grid_pin_3_ left_top_grid_pin_5_
+ left_top_grid_pin_7_ left_top_grid_pin_9_ pReset prog_clk VPWR VGND
Xmux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_13_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_100 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_126 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_12 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_10_114 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_left_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _26_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _54_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
X_49_ _49_/A chany_bottom_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_15_6 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_65 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_21 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_23 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_45 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_54 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_10 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_145 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_123 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_1_ mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_3_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_55 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_11 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_98 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_bottom_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_48_ _48_/A chany_bottom_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_20_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_121 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[0] mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_77 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__fill_1
X_47_ _47_/A chany_bottom_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_22 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_3_ mux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_19_152 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_13_ mux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xclkbuf_2_1_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mux_bottom_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _31_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_118 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_48 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_124 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_46_ _46_/A chanx_left_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _21_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_29_ _29_/HI _29_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_92 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _40_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_19_131 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_79 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _20_/HI mux_left_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_16_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_134 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_133 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _25_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_46 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _43_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_26 VGND VPWR sky130_fd_sc_hd__fill_2
X_45_ _45_/A chanx_left_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_46 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_35 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_28_ _28_/HI _28_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[4] mux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_6_27 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_102 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_69 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_58 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_47 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_14 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _29_/HI mux_bottom_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _28_/HI mux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_70 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_15 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_145 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_9_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_58 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_14 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_82 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_44_ _44_/A chanx_left_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[7] mux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_18_58 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_27_ _27_/HI _27_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_15 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ ccff_tail mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N _19_/Y
+ clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_144 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_81 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_80 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_139 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_82 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_110 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__42__A _42_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_0_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_116 VGND VPWR sky130_fd_sc_hd__decap_8
X_43_ _43_/A chanx_left_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_18_15 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_91 VGND VPWR sky130_fd_sc_hd__fill_1
X_26_ _26_/HI _26_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _36_/HI mux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_1_95 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__50__A _50_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_7_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_123 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_80 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_93 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_25_137 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__45__A _45_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_126 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_107 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_118 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _30_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_bottom_grid_pin_12_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_8 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__53__A _53_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_42_ _42_/A chanx_left_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _20_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__48__A _48_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_25_ _25_/HI _25_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_113 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_102 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_19_135 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_149 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_119 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _55_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[2] mux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_101 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _26_/HI mux_left_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_30 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _24_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_129 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_151 VGND VPWR sky130_fd_sc_hd__fill_2
X_41_ _41_/A chanx_left_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _47_/A VGND VPWR sky130_fd_sc_hd__inv_1
X_24_ _24_/HI _24_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[2] mux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_60 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[7] mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_74 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_83 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_18 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_86 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_97 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_40_ _40_/A chanx_left_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_24_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_72 VGND VPWR sky130_fd_sc_hd__decap_8
X_23_ _23_/HI _23_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_19_50 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_left_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_143 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_132 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_40 VGND VPWR sky130_fd_sc_hd__decap_8
X_22_ _22_/HI _22_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_99 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_88 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _36_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_19_127 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N _19_/Y clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_24_141 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_15_130 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_87 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_11.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _29_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_30 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_12_100 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _41_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_66 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_53 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_143 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_13_ mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_21_ _21_/HI _21_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_45 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_34 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_139 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_98 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_87 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_20 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _44_/A VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_123 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[0] mux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_16_97 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_75 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_145 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[5] mux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_4_12 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_23 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_78 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _37_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_21 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_20 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_20_ _20_/HI _20_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_57 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_10_44 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_121 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_7_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_102 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_left_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _21_/HI mux_left_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_1_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_119 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_54 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_133 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _51_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_7_ mux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_147 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_136 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_11 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_5_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_36 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_bottom_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _30_/HI mux_bottom_track_13.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_13_12 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _33_/HI mux_bottom_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_bottom_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _35_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_109 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_13_ mux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_15_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_101 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_134 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_103 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_56 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_1_49 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_9_ mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _37_/HI mux_left_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_7_15 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _48_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_16_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_46 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_35 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_120 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_16 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_27 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_145 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_35 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_24 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_13 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_15 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_71 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_36 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__19__A pReset VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_106 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_16_14 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_70 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_11.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_4_124 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_3_ mux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_13_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_127 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _27_/HI mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_14_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_29 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_69 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_27 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_101 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__40__A _40_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_83 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_126 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_7 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_81 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_26 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_136 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_16 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_139 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__43__A _43_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_83 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__38__A _38_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _34_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_124 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_left_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_16 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__51__A _51_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_5_ mux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_15_ mux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__46__A _46_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_7_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_145 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_19 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _45_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_51 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__54__A _54_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_70 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__49__A _49_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_70 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_39_ _39_/A chanx_left_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_21_7 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_84 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_5_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_7.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_24_28 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_39 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_28 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_17 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_19 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_13.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_60 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_71 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_55_ _55_/A chany_bottom_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_75 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_62 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[5] mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_14_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_18 VGND VPWR sky130_fd_sc_hd__decap_6
X_38_ _38_/A chanx_left_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_7_114 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_50 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_128 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _52_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_120 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_20 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_84 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_3_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_116 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_105 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_61 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_72 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[8] mux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_54_ _54_/A chany_bottom_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_130 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_3.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_3.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_37_ _37_/HI _37_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_40 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_133 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_97 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_11_ mux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_1_ mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_110 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_30 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _33_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _22_/HI mux_left_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_40 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_73 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_55 VGND VPWR sky130_fd_sc_hd__fill_2
X_53_ _53_/A chany_bottom_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_62 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_53 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_31 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_134 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_123 VGND VPWR sky130_fd_sc_hd__decap_8
X_36_ _36_/HI _36_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_22_96 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_112 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_21 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_19_ pReset _19_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_0_133 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_55 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _49_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_14_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _31_/HI mux_bottom_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_25_85 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_52 VGND VPWR sky130_fd_sc_hd__fill_2
X_52_ _52_/A chany_bottom_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_129 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_23 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _34_/HI mux_bottom_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_52 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_63 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_35_ _35_/HI _35_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_22_64 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_97 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[3] mux_bottom_track_5.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_145 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _38_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_64 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_130 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_51_ _51_/A chany_bottom_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_77 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_66 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[3] mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_34_ _34_/HI _34_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_13.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_129 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[6] mux_bottom_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_17_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_54 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_110 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _24_/HI mux_left_track_3.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_3.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_0_102 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_24 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_88 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_11 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_25_98 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_50_ _50_/A chany_bottom_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_23_145 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_134 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_34 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_7 VGND VPWR sky130_fd_sc_hd__fill_2
X_33_ _33_/HI _33_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_left_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_11 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_133 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_7.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_69 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_13.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_13.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_25_66 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _28_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_110 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_2_59 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _46_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_14_135 VGND VPWR sky130_fd_sc_hd__fill_2
X_32_ _32_/HI _32_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_22_56 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_25 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_145 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_35 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_left_in[1] mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_56 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_27 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_67 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_bottom_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_11.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_11.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_23_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_3.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_3_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_31_ _31_/HI _31_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_68 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_8_59 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_35 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_102 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[1] mux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_9_91 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[6] mux_left_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_101 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_68 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_145 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_134 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_126 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _53_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_14_104 VGND VPWR sky130_fd_sc_hd__fill_2
X_30_ _30_/HI _30_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_107 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_130 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_71 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_69 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_1_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_26 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_15 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_13.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_left_track_11.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_149 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_11_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__41__A _41_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_119 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_108 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_17 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_145 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_9_ mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_bottom_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_15.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA__44__A _44_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_72 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_83 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__39__A _39_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_139 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_13.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_11.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _50_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_7.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_7.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_15_ mux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__52__A _52_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_81 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_70 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__47__A _47_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _23_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_39 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_16 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[8] mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[4] mux_left_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_17_126 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_104 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__55__A _55_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_118 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_left_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _23_/HI mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _39_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_6_114 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _27_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_106 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_3_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_5.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_93 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_41 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_28 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _42_/A VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_83 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_108 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_13.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_11.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_134 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_75 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _32_/HI mux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _35_/HI mux_bottom_track_7.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_129 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_23_94 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_50 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_54 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_30 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_85 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_40 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_5_ mux_bottom_track_5.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_11.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_51 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_131 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_track_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_102 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_15.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_15_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_8 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_15.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_15.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_17_7 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_5.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_5.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_9_42 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_11_ mux_bottom_track_11.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_18_84 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_bottom_track_3.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_3.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_96 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_32 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_98 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _25_/HI mux_left_track_5.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_5.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_118 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _32_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_44 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_15.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_15.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_15.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_9_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_30 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_7_ mux_left_track_7.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1 left_bottom_grid_pin_12_ mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_9_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_1_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_30 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_13.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_15.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_left_track_15.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _22_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_2_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_7.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_75 VGND VPWR sky130_fd_sc_hd__fill_2
.ends
