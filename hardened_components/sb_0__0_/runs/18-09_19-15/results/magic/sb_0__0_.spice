* NGSPICE file created from sb_0__0_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__ebufn_1 abstract view
.subckt sky130_fd_sc_hd__ebufn_1 A TE_B Z VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A Y VGND VPWR
.ends

.subckt sb_0__0_ ccff_head ccff_tail chanx_right_in[0] chanx_right_in[1] chanx_right_in[2]
+ chanx_right_in[3] chanx_right_in[4] chanx_right_in[5] chanx_right_in[6] chanx_right_in[7]
+ chanx_right_in[8] chanx_right_out[0] chanx_right_out[1] chanx_right_out[2] chanx_right_out[3]
+ chanx_right_out[4] chanx_right_out[5] chanx_right_out[6] chanx_right_out[7] chanx_right_out[8]
+ chany_top_in[0] chany_top_in[1] chany_top_in[2] chany_top_in[3] chany_top_in[4]
+ chany_top_in[5] chany_top_in[6] chany_top_in[7] chany_top_in[8] chany_top_out[0]
+ chany_top_out[1] chany_top_out[2] chany_top_out[3] chany_top_out[4] chany_top_out[5]
+ chany_top_out[6] chany_top_out[7] chany_top_out[8] pReset prog_clk right_bottom_grid_pin_11_
+ right_bottom_grid_pin_13_ right_bottom_grid_pin_15_ right_bottom_grid_pin_1_ right_bottom_grid_pin_3_
+ right_bottom_grid_pin_5_ right_bottom_grid_pin_7_ right_bottom_grid_pin_9_ right_top_grid_pin_10_
+ top_left_grid_pin_11_ top_left_grid_pin_13_ top_left_grid_pin_15_ top_left_grid_pin_1_
+ top_left_grid_pin_3_ top_left_grid_pin_5_ top_left_grid_pin_7_ top_left_grid_pin_9_
+ top_right_grid_pin_11_ VPWR VGND
XFILLER_7_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _36_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_137 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_126 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_10 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_103 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_151 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _36_/HI mux_right_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
X_49_ _49_/A chany_top_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_top_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _50_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _30_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_5_ mux_top_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_15_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _27_/HI mux_top_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_22_101 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_145 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_105 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_0_58 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_67 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_12 VGND VPWR sky130_fd_sc_hd__fill_2
X_48_ _48_/A chany_top_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_top_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_7 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_6.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_6.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_20_44 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_55 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_66 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_13 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_88 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_113 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_top_track_6.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_6.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_1_ mux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_5_ VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_67 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_88 VGND VPWR sky130_fd_sc_hd__fill_2
X_47_ _47_/A chany_top_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _53_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_18_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_44 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_34 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_23 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xclkbuf_2_1_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_136 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[7] mux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_3_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_57 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_128 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_6.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _26_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_143 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_45 VGND VPWR sky130_fd_sc_hd__fill_2
X_46_ _46_/A chanx_right_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_right_grid_pin_11_ mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_1_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_36 VGND VPWR sky130_fd_sc_hd__fill_2
X_29_ _29_/HI _29_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_6_48 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_142 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_131 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_25_123 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_right_track_6.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _35_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_118 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _40_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_1_ mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_111 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_114 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_45_ _45_/A chanx_right_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_18_57 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_4.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_4.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _29_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_28_ _28_/HI _28_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_15_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_102 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_105 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_4.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_4.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_39 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_109 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_131 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_37 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_9 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_36 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_16 VGND VPWR sky130_fd_sc_hd__decap_4
X_44_ _44_/A chanx_right_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_top_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__fill_2
X_27_ _27_/HI _27_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_26 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _43_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_92 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_37 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_114 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_93 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _32_/HI mux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_0_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__42__A _42_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_15 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_7 VGND VPWR sky130_fd_sc_hd__fill_2
X_43_ _43_/A chanx_right_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[5] mux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_10.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_91 VGND VPWR sky130_fd_sc_hd__fill_1
X_26_ _26_/HI _26_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_51 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_73 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_84 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__50__A _50_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_18 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_top_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_13_ mux_top_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_25_115 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_27 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__45__A _45_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_140 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_4.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _25_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__53__A _53_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_49 VGND VPWR sky130_fd_sc_hd__fill_2
X_42_ _42_/A chanx_right_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA__48__A _48_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_25_ _25_/HI _25_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_top_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_41 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_2_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_146 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_135 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[4] mux_top_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_top_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _23_/HI mux_top_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_93 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_108 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_73 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_71 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_145 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[2] mux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_4.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _34_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_2.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _33_/HI mux_right_track_2.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_129 VGND VPWR sky130_fd_sc_hd__decap_8
X_41_ _41_/A chanx_right_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_140 VGND VPWR sky130_fd_sc_hd__decap_12
X_24_ _24_/HI _24_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_top_track_2.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _24_/HI mux_top_track_2.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_61 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_83 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_102 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_top_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_top_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_127 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_42 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_53 VGND VPWR sky130_fd_sc_hd__decap_8
X_40_ _40_/A chanx_right_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_right_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_152 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_top_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_7 VGND VPWR sky130_fd_sc_hd__fill_2
X_23_ _23_/HI _23_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_32 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_top_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_3_ VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_129 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_129 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_118 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_64 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_top_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _54_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_114 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_5_139 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_19 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_98 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_87 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_76 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_65 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_41 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
X_22_ _22_/HI _22_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_11 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_77 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_88 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_152 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1_A right_top_grid_pin_10_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_21_144 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_16_74 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[2] mux_top_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_2.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _24_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_53 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[0] mux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_21_ _21_/HI _21_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_top_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_1_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_85 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _41_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_19_41 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_64 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_88 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_55 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_16_53 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_20 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_123 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_2.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _33_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_53 VGND VPWR sky130_fd_sc_hd__fill_2
X_20_ _20_/HI _20_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_19_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_66 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_11 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_19_97 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_132 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_113 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_12 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_139 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _44_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_13_ mux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_13_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_10 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_47 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_32 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _29_/HI mux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[8] mux_top_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_55 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_144 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _47_/A VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_133 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_151 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_124 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_23 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_24_22 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_88 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_7 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_123 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_top_track_6.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_145 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_7_ mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_2_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_67 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _37_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_26 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_136 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_6 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_38 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_top_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _20_/HI mux_top_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_19_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_6.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_68 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_102 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_59 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_57 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_127 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _28_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_38 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_104 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_90 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_right_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_26 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_9_ mux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_18_111 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_7_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_71 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_82 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_114 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__19__A pReset VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_16 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_7_ mux_top_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_7_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_110 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[6] mux_top_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_1_ VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_70 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_37 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _55_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_60 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_4.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _34_/HI mux_right_track_4.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_10_16 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__40__A _40_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_134 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_94 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_7 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_4.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _25_/HI mux_top_track_4.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_12_118 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_122 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_82 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_114 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_13_27 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_3_ mux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__43__A _43_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__38__A _38_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_37 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_2.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_2.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_62 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_27 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__51__A _51_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_16 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__46__A _46_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_70 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_2.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_2.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_73 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_40 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__54__A _54_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_27 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N _19_/Y clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_70 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__49__A _49_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_139 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_106 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_83 VGND VPWR sky130_fd_sc_hd__fill_2
X_39_ _39_/A chanx_right_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_109 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_28 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_150 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_131 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_108 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_3_ mux_top_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _45_/A VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_60 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_71 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_71 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_126 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_115 VGND VPWR sky130_fd_sc_hd__fill_2
X_55_ _55_/A chany_top_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_42 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_53 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_top_track_4.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_40 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_38_ _38_/A chanx_right_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_50 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_top_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _48_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_9 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _23_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_62 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_72 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_4.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_54_ _54_/A chany_top_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1 right_top_grid_pin_10_ mux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_2_98 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_130 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_52 VGND VPWR sky130_fd_sc_hd__fill_2
X_37_ _37_/HI _37_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmem_top_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_126 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_8_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_17_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_129 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_top_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_9_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_32 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_41 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[6] mux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_53_ _53_/A chany_top_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_73 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_40 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_97 VGND VPWR sky130_fd_sc_hd__decap_4
X_36_ _36_/HI _36_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_9_ VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_2.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_134 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_145 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_15_ mux_top_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_11_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_138 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_98 VGND VPWR sky130_fd_sc_hd__fill_2
X_19_ pReset _19_/Y VGND VPWR sky130_fd_sc_hd__inv_8
Xmux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _30_/HI mux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_6 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _51_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_88 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_53 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_52_ _52_/A chany_top_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_63 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_85 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_2.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_132 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_143 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_87 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_32 VGND VPWR sky130_fd_sc_hd__fill_1
X_35_ _35_/HI _35_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_11_135 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_106 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[5] mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_8_22 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_5_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[3] mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_64 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_119 VGND VPWR sky130_fd_sc_hd__decap_3
X_51_ _51_/A chany_top_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_top_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_34_ _34_/HI _34_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_top_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _21_/HI mux_top_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_20_114 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _38_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_78 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_54 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_10 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_68 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_14.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _22_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_66 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_65 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_98 VGND VPWR sky130_fd_sc_hd__fill_2
X_50_ _50_/A chany_top_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_131 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_120 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_56 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_12 VGND VPWR sky130_fd_sc_hd__fill_2
X_33_ _33_/HI _33_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ ccff_tail mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N _19_/Y
+ clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_126 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[4] mux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_22_55 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_126 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_10.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_10.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_8_57 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_top_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_88 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_133 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_11_ mux_top_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_147 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_36 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_66 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_26 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_143 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_6.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _35_/HI mux_right_track_6.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
X_32_ _32_/HI _32_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_80 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_12 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_14 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_131 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_101 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_145 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_6.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _26_/HI mux_top_track_6.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[3] mux_top_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_7 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_top_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[1] mux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_67 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_38 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_23 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_67 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_147 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_36 VGND VPWR sky130_fd_sc_hd__fill_2
X_31_ _31_/HI _31_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_top_track_10.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_10.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_26 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_top_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _46_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_3_113 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _32_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_16 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_top_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_68 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_3 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_126 VGND VPWR sky130_fd_sc_hd__fill_2
X_30_ _30_/HI _30_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_top_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _49_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_9_141 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_47 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_50 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_26 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_15_ mux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _21_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_82 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_71 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_69 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_top_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_23_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_16 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA__41__A _41_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_50 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_61 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_72 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_119 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[0] mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_80 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_top_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_71 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_80 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_7_ VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__44__A _44_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_70 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[1] mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__39__A _39_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_147 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_top_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _52_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_121 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[8] mux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__52__A _52_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_60 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__47__A _47_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_105 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_70 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_2_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mux_top_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_62 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__55__A _55_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_93 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_3_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_3 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_140 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_17 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_83 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_72 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_132 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_117 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_3_0_prog_clk clkbuf_2_2_0_prog_clk/A clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_24_6 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_84 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_40 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_109 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_right_track_14.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _31_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_right_track_14.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _31_/HI mux_right_track_14.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _39_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_20_83 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_141 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_11_ mux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_right_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_144 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_54 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_6 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_9_ mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[7] mux_top_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_top_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _20_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_15_84 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_131 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_32 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_54 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_65 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _42_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_123 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_top_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_108 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _19_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_44 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _19_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_right_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_75 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_14.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _22_/HI mux_top_track_14.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_18_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_30 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_98 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _28_/HI mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_5_ mux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_41 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_132 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _37_/HI mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _27_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_53 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_139 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_78 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_32 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_10.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_top_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xclkbuf_2_2_0_prog_clk clkbuf_2_2_0_prog_clk/A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_55 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_44 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_15_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_53 VGND VPWR sky130_fd_sc_hd__fill_2
.ends
