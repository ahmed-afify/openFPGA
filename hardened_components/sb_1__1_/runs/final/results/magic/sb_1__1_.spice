* NGSPICE file created from sb_1__1_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__ebufn_1 abstract view
.subckt sky130_fd_sc_hd__ebufn_1 A TE_B Z VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A Y VGND VPWR
.ends

.subckt sb_1__1_ bottom_left_grid_pin_13_ bottom_right_grid_pin_11_ ccff_head ccff_tail
+ chanx_left_in[0] chanx_left_in[1] chanx_left_in[2] chanx_left_in[3] chanx_left_in[4]
+ chanx_left_in[5] chanx_left_in[6] chanx_left_in[7] chanx_left_in[8] chanx_left_out[0]
+ chanx_left_out[1] chanx_left_out[2] chanx_left_out[3] chanx_left_out[4] chanx_left_out[5]
+ chanx_left_out[6] chanx_left_out[7] chanx_left_out[8] chanx_right_in[0] chanx_right_in[1]
+ chanx_right_in[2] chanx_right_in[3] chanx_right_in[4] chanx_right_in[5] chanx_right_in[6]
+ chanx_right_in[7] chanx_right_in[8] chanx_right_out[0] chanx_right_out[1] chanx_right_out[2]
+ chanx_right_out[3] chanx_right_out[4] chanx_right_out[5] chanx_right_out[6] chanx_right_out[7]
+ chanx_right_out[8] chany_bottom_in[0] chany_bottom_in[1] chany_bottom_in[2] chany_bottom_in[3]
+ chany_bottom_in[4] chany_bottom_in[5] chany_bottom_in[6] chany_bottom_in[7] chany_bottom_in[8]
+ chany_bottom_out[0] chany_bottom_out[1] chany_bottom_out[2] chany_bottom_out[3]
+ chany_bottom_out[4] chany_bottom_out[5] chany_bottom_out[6] chany_bottom_out[7]
+ chany_bottom_out[8] chany_top_in[0] chany_top_in[1] chany_top_in[2] chany_top_in[3]
+ chany_top_in[4] chany_top_in[5] chany_top_in[6] chany_top_in[7] chany_top_in[8]
+ chany_top_out[0] chany_top_out[1] chany_top_out[2] chany_top_out[3] chany_top_out[4]
+ chany_top_out[5] chany_top_out[6] chany_top_out[7] chany_top_out[8] left_bottom_grid_pin_12_
+ left_top_grid_pin_10_ pReset prog_clk right_bottom_grid_pin_12_ right_top_grid_pin_10_
+ top_left_grid_pin_13_ top_right_grid_pin_11_ VPWR VGND
Xmux_right_track_0.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_22_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_166 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_89 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_78 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_129 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_40 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _23_/HI mux_right_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_206 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_top_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_8.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_33 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_77 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_1_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_0.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_49_ chany_top_in[2] chany_bottom_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
Xclkbuf_3_4_0_prog_clk clkbuf_3_5_0_prog_clk/A clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xmux_right_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_220 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_7 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_194 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_30 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_109 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_186 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_109 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_175 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_76 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_left_track_1.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1 chanx_left_in[0] mux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_16_197 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_156 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[0] mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_68 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_46 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_215 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1 chanx_left_in[6] mux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_8_182 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_207 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_215 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_196 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_207 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_10 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_48_ _48_/A chany_bottom_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_20 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chanx_left_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_118 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1 chanx_left_in[4] mux_top_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_4_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_44 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_35 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_162 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_173 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1 chany_bottom_in[6] mux_right_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chanx_right_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_110 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_65 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_179 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_146 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1 chanx_left_in[0] mux_right_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_30_190 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_146 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _14_/HI mux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_8.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_8.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[6] mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_149 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_45 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1 chany_bottom_in[6] mux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_37_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_219 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_164 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_175 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_219 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_22 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[3] mux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_2_189 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_57 VGND VPWR sky130_fd_sc_hd__fill_2
X_47_ chany_top_in[4] chany_bottom_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_44 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_77 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_88 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1 chany_bottom_in[8] mux_left_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_8.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_47 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_122 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_177 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_bottom_track_1.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_56 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_22 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_16_133 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_114 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_177 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1 chany_bottom_in[0] mux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_16.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_1_0_prog_clk clkbuf_1_0_0_prog_clk/X clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_22_125 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_136 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_147 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_left_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1_A left_bottom_grid_pin_12_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_66 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_55 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_22 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_88 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_26 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[1] mux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_8_162 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_87 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A _16_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1 right_top_grid_pin_10_ mux_right_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_132 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_124 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_113 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_46_ chany_top_in[5] chany_bottom_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1 chanx_right_in[0] mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_20_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_23 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_top_track_0.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_44 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_212 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_9 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_70 VGND VPWR sky130_fd_sc_hd__fill_1
X_29_ chanx_right_in[4] chanx_left_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_66 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_120 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_3_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_34_145 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[0] mux_left_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_31_104 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_145 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_159 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[6]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_80 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_104 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_0.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_27_207 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_129 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_36 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_13_ mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1_A chanx_left_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_144 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1 chanx_left_in[6] mux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_221 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_23_57 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_26 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_221 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_0.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_45_ chany_top_in[6] chany_bottom_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_13 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1 chany_bottom_in[4] mux_right_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_16.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_0.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_28_ chanx_right_in[5] chanx_left_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_right_track_0.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_16 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_91 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_25_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_146 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_179 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_57 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__31__A chanx_right_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_193 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_219 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1 chany_bottom_in[3] mux_left_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_45 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__26__A _26_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__fill_2
X_61_ _61_/A chany_top_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_200 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_1.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_14 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_211 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chanx_left_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chanx_right_in[2]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_49 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_80 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_6 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_44_ _44_/A chany_bottom_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_192 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[8] mux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_34_57 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_3_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_27_ chanx_right_in[6] chanx_left_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_26 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_46 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_188 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_177 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_133 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__34__A _34_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_28 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_221 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_right_track_8.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_20_9 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_166 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_177 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_125 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_top_in[4] mux_right_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_25_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_14 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_213 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__29__A chanx_right_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_125 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_183 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_161 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_18 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ mux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_8_198 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_8.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_top_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA__42__A chanx_left_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_168 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_179 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_0_0_prog_clk clkbuf_1_0_0_prog_clk/X clkbuf_3_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_60_ chany_bottom_in[0] chany_top_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_right_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_23_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_201 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__37__A chanx_left_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_top_in[8] mux_left_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_43_ _43_/A chanx_right_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_204 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_215 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_left_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_34_36 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_178 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_167 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_156 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__decap_8
X_26_ _26_/A chanx_left_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_28_145 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__50__A chany_top_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_82 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_93 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_19_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_159 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_203 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_118 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__45__A chany_top_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_192 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_left_track_9.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_72 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xclkbuf_3_2_0_prog_clk clkbuf_3_3_0_prog_clk/A clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_26_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_118 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_221 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_103 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_16.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_4_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_73 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_62 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__53__A _53_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_42_ chanx_left_in[0] chanx_right_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chanx_left_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[6] mux_left_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_left_track_17.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_15 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_209 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__48__A _48_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_25_ _25_/HI _25_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_26 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_50 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_116 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_146 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1 chanx_left_in[5] mux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_9.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_149 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__61__A _61_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_top_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_40 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _52_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__56__A chany_bottom_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_71 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chanx_left_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chanx_right_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_145 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_37_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_148 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_70 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_211 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_30 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_9.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_107 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_41_ chanx_left_in[1] chanx_right_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _44_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _14_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_71 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1_A chanx_left_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_221 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_53 VGND VPWR sky130_fd_sc_hd__fill_2
X_24_ _24_/HI _24_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_29 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_28_125 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A _21_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_213 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__59__A chany_bottom_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[1] mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_32_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_106 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_150 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_117 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_50 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_120 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_186 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_175 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_131 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_113 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[5] mux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_left_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_49 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_27 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_26_212 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_18 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_14_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_163 VGND VPWR sky130_fd_sc_hd__fill_2
X_40_ chanx_left_in[2] chanx_right_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_28 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chanx_left_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_83 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_7 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_137 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_1_21 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_43 VGND VPWR sky130_fd_sc_hd__decap_4
X_23_ _23_/HI _23_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_192 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_50 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_129 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_18 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1 chanx_left_in[6] mux_right_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_129 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_left_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_31 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_18 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_165 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1_A chanx_left_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_84 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_180 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_128 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[8] mux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1 chanx_left_in[7] mux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xclkbuf_3_1_0_prog_clk clkbuf_3_1_0_prog_clk/A clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xmux_bottom_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_30 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_131 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1 chanx_left_in[2] mux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_13_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_175 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_220 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_208 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_149 VGND VPWR sky130_fd_sc_hd__decap_6
X_22_ _22_/HI _22_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_116 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_42 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_97 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_116 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_163 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_193 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_218 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_right_track_16.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_21_85 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_163 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_65 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_98 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1 chanx_left_in[3] mux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_177 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1 chany_bottom_in[2] mux_right_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_107 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_206 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1 chany_bottom_in[7] mux_right_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_4_195 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_99 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_11 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_53 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_left_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_143 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[2] mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1 chany_bottom_in[2] mux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_37_106 VGND VPWR sky130_fd_sc_hd__decap_12
X_21_ _21_/HI _21_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_89 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A _15_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1 chanx_right_in[0] mux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_36_183 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_85 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_175 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chanx_right_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1 chany_bottom_in[6] mux_left_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_24_120 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_175 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_145 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_44 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_30_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_112 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_16_75 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_149 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_145 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_8.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_171 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_193 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_204 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[7] mux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_4_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_163 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_207 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_100 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_8.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A _24_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_top_in[8] mux_right_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_221 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_37_118 VGND VPWR sky130_fd_sc_hd__decap_6
X_20_ _20_/HI _20_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_bottom_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_1_57 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_left_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_129 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_11 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_10_66 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_85 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_110 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_right_track_8.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_209 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_clkbuf_3_4_0_prog_clk_A clkbuf_3_5_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_132 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_10 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_54 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_132 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_23 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_146 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_157 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_179 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_135 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_75 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_top_in[4] mux_left_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_53 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_31 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_97 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_46 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_35 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_219 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_66 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_112 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_212 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_0.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 _22_/HI mux_right_track_0.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_0_0_prog_clk clkbuf_3_1_0_prog_clk/A clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xmux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1 chanx_left_in[2] mux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_8.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_32 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_87 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_left_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_47 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_54 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_97 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_163 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_152 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_8 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1 chany_bottom_in[3] mux_right_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _48_/A VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_177 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_188 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_125 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_57 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chanx_right_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _53_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_0.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 _25_/HI mux_top_track_0.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_16_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_88 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_43 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_129 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_151 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_184 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_65 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_58 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_34 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_45 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_179 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_135 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_220 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1 chany_bottom_in[0] mux_left_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1_A chanx_left_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_201 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[2]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_186 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_right_track_0.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_10_46 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_175 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_7 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_131 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1 chanx_right_in[6] mux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chanx_left_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_145 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_89 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_69 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_104 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[3] mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_35_207 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_192 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 _24_/HI mux_right_track_8.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_0.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_17_207 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_221 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _23_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1 chany_bottom_in[7] mux_left_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_67 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__13__A pReset VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_206 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_top_track_0.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_8.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 _15_/HI mux_top_track_8.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[6] mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_35_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_89 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_179 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_146 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_left_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_30_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_179 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chanx_left_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_6 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_116 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_149 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_193 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_219 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_197 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_34 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_219 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_211 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1_A chanx_left_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_1_159 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_0.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_92 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_70 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_17 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_28 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_39 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_90 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_177 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_right_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_35_12 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_103 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[2] mux_left_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_18_177 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
X_59_ chany_bottom_in[1] chany_top_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_93 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_136 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_103 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_114 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_79 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_35 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_139 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_1.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1 chanx_left_in[1] mux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_7_176 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__32__A chanx_right_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_179 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_13_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_127 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA__27__A chanx_right_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_212 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _61_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_215 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_left_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_36_101 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_38 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_57 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__40__A chanx_left_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_145 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_159 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_58_ chany_bottom_in[2] chany_top_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_159 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__35__A _35_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_207 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_69 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_80 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_93 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_125 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_103 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_18 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1 chanx_left_in[4] mux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_16_221 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _20_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_139 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1 chanx_right_in[1] mux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__43__A _43_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__38__A chanx_left_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_220 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chanx_left_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_179 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_146 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_201 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_left_track_9.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_73 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_40 VGND VPWR sky130_fd_sc_hd__decap_8
X_57_ _57_/A chany_top_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_24_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_193 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__51__A chany_top_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_82 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_193 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_219 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_16 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_27 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA__46__A chany_top_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_156 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_167 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1 chanx_left_in[2] mux_right_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chanx_left_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_211 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_195 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_40 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[6] mux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_24_16 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_27 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1 chanx_left_in[5] mux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_206 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_3_0_0_prog_clk_A clkbuf_3_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_7 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__54__A chany_bottom_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_71 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_82 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_114 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 _16_/HI mux_bottom_track_1.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_13_ mux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_19_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_213 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__49__A chany_top_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N _13_/Y clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_70 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_70 VGND VPWR sky130_fd_sc_hd__decap_3
X_56_ chany_bottom_in[4] chany_top_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_139 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_128 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_91 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_39_ _39_/A chanx_right_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_32_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_131 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_197 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_left_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_135 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[8]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_93 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_73 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_84 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_clkbuf_3_5_0_prog_clk_A clkbuf_3_5_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_38 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__57__A _57_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_201 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1 chanx_left_in[0] mux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_93 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_108 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_top_in[7] mux_right_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_9_208 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_163 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_30 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_right_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1 chany_bottom_in[5] mux_right_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chanx_left_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_16 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_159 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_9.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_71 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_107 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_60 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1 chanx_right_in[4] mux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_55_ chany_bottom_in[5] chany_top_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_17_170 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_181 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_15_107 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_162 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[5] mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_38_ chanx_left_in[4] chanx_right_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_32_39 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_28_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_114 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_165 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1 chany_bottom_in[2] mux_left_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_8_30 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_161 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_150 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 _18_/HI mux_bottom_track_9.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_0_120 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_28_71 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_5_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_16.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1 chanx_right_in[5] mux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_left_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_212 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_61 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_127 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_right_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_27_105 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_149 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_72 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_193 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[6] mux_right_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_54_ chany_bottom_in[6] chany_top_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_21_19 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1 chanx_left_in[5] mux_right_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _17_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_174 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_30 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_71 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_93 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
X_37_ chanx_left_in[5] chanx_right_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_177 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_200 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_40 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_211 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_97 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1_A chanx_left_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_184 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_140 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_110 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[3] mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chanx_right_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1 left_bottom_grid_pin_12_ mux_left_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_8_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_221 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_9.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_14_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_139 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_left_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_7 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_73 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
X_53_ _53_/A chany_top_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_11 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_99 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_197 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1 chany_bottom_in[5] mux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_11_86 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_3 VGND VPWR sky130_fd_sc_hd__fill_2
X_36_ chanx_left_in[6] chanx_right_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_32_19 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_right_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_145 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_212 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A _18_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_134 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1 chany_bottom_in[0] mux_right_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_34_215 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_19_ _19_/HI _19_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_207 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_95 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_8.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _57_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_133 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_66 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_bottom_track_17.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_86 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_97 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_151 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[5] mux_left_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_30 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_74 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_41 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_52_ _52_/A chany_bottom_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_98 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_35_ _35_/A chanx_right_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_135 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_139 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_102 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_64 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_0.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[2] mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_8_11 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_22 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_194 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_left_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
X_18_ _18_/HI _18_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chanx_left_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XPHY_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_52 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_219 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_right_track_8.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_97 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_85 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_197 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_175 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_7 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[0] mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_left_track_1.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_208 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_178 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _26_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_0.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_left_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_163 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_207 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_64 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_53 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_75 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_75 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A _19_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_51_ chany_top_in[0] chany_bottom_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_32_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_133 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_122 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1 chany_bottom_in[5] mux_left_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_left_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_top_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_174 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_55 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_177 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[2] mux_left_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_34_ _34_/A chanx_left_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_192 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chanx_left_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_169 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _35_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_34_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_162 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_top_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
X_17_ _17_/HI _17_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mem_right_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_10 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_110 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_165 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_right_track_0.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chanx_left_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_102 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_86 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_75 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_24 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_13 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_55 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1_A right_top_grid_pin_10_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_175 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_65 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_54 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_right_track_8.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_top_track_0.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_50_ chany_top_in[1] chany_bottom_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_0.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_0.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_32_145 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_34 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_45 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_101 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_145 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_215 VGND VPWR sky130_fd_sc_hd__fill_2
X_33_ chanx_right_in[0] chanx_left_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_left_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_171 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_204 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_left_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_top_in[7] mux_left_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_22_11 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_left_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_35 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_right_track_8.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_16_ _16_/HI _16_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_26_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_207 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_8.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_66 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_21 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _20_/HI mux_left_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_3_144 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_top_track_0.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_30_221 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_21 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_147 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_11_ mux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_12_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_36 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_77 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_7_0_prog_clk clkbuf_3_6_0_prog_clk/A clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_121 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_66 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_220 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_143 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_1_0_prog_clk_A clkbuf_3_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_146 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_179 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_10 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chanx_left_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_8.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _34_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_22_190 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_7 VGND VPWR sky130_fd_sc_hd__fill_2
X_32_ chanx_right_in[1] chanx_left_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_116 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_127 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_138 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_47 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_193 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_right_track_16.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_15_ _15_/HI _15_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_219 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_99 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_123 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_0.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _17_/HI mux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_8.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_28_55 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_159 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_215 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_right_track_8.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_clkbuf_3_6_0_prog_clk_A clkbuf_3_6_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1 chanx_left_in[3] mux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_30_23 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_89 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_163 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_152 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_9.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[4] mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_0.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A _25_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_133 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1 chanx_left_in[8] mux_bottom_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_177 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_125 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_158 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_69 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_36_55 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_top_track_8.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_14_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_136 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_31_ chanx_right_in[2] chanx_left_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_top_track_0.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_140 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_180 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_68 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_left_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_14_ _14_/HI _14_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_right_track_0.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_89 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_102 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _43_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_3_179 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_67 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1 chany_bottom_in[8] mux_right_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_12_201 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_14 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_0.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A _22_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_208 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1 chanx_left_in[4] mux_right_track_0.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_29_175 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_101 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_145 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__30__A _30_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1 chanx_right_in[2] mux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_17_123 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1 chanx_left_in[1] mux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_0.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_67 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_218 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_207 VGND VPWR sky130_fd_sc_hd__decap_8
X_30_ _30_/A chanx_left_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[4] mux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_13_170 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_192 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_196 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_11_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_36 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_1_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_207 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_7 VGND VPWR sky130_fd_sc_hd__decap_4
X_13_ pReset _13_/Y VGND VPWR sky130_fd_sc_hd__inv_8
Xmux_left_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1 left_top_grid_pin_10_ mux_left_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[8]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_0.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_70 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_81 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_D mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_79 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__33__A chanx_right_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_17 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_26 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1 chany_bottom_in[4] mux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_30_36 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__28__A chanx_right_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_146 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_113 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[5] mux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_7_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_69 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_190 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_18 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_113 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_116 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_right_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_6_0_prog_clk clkbuf_3_6_0_prog_clk/A clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xmux_right_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1 chany_bottom_in[1] mux_right_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_14_149 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__41__A chanx_left_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_9_175 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_left_track_17.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_15 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[3] mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__36__A chanx_left_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_219 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_178 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_26 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_25 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[1] mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_15_211 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_0_40 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_right_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_25 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[4] mux_left_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_0.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_100 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__44__A _44_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_221 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_1.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 _19_/HI mux_left_track_1.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chanx_left_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_top_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[6]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_59 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_125 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_37 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__39__A _39_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_70 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1 chanx_right_in[1] mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_23_117 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_150 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_top_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1 chanx_left_in[8] mux_top_track_8.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_track_1.sc_dff_compact_7_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_183 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_27 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[2] mux_right_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__52__A _52_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_18 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1 chanx_left_in[1] mux_right_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_19_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_127 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chanx_left_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA__47__A chany_top_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_215 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_right_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_12_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__60__A chany_bottom_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_35_159 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_73 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_84 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[0] mux_left_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1 chany_bottom_in[4] mux_left_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_9_6 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__55__A chany_bottom_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_129 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_1.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_left_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_1.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_16_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chanx_right_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_140 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_74 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_36_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_96 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_85 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_track_1.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1/D mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_61 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1 chany_bottom_in[1] mux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_18_221 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_left_track_9.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 _21_/HI mux_left_track_9.mux_l2_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_9.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_3_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_3_6_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_right_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_12_ mux_right_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__58__A chany_bottom_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_18 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_190 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_left_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_top_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_179 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_146 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_right_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_29_92 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_149 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_116 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_left_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _30_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chanx_left_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_127 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_163 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_193 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_152 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_174 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_167 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_42 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[1] mux_left_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chanx_right_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1_A left_top_grid_pin_10_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_10_177 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_73 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_84 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_5_0_prog_clk clkbuf_3_5_0_prog_clk/A clkbuf_3_5_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xmux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_1_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_5_192 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A
+ mux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_3_118 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_left_track_17.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_left_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_140 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_162 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_6 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_41 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_right_grid_pin_11_ mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_28_17 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_206 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_left_track_9.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_left_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_9.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_7_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_117 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_top_track_16.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_0_.TGATE_3_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_6_20 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_97 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_183 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_left_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_left_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_left_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_left_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_15_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_139 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_4_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_31_175 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_17 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_7_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_120 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_186 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_19 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_left_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1 chany_bottom_in[1] mux_left_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_left_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_left_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _39_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_145 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_201 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_3_2_0_prog_clk_A clkbuf_3_3_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_160 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_174 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_152 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_17.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_2_185 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_8 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_207 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_97 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_5_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1 chanx_left_in[7] mux_bottom_track_1.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_18_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_73 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_84 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_6_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_left_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_159 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_129 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ mux_right_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_195 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_6_.sky130_fd_sc_hd__dfrbp_1_RESET_B _13_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_7_0_prog_clk_A clkbuf_3_6_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_52 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_8_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chanx_left_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_1_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_114 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_136 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_213 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_bottom_track_9.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_113 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ ccff_tail mem_left_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N _13_/Y
+ clkbuf_3_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_61 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_85 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_6_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_10 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_219 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[5] mux_left_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_8.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_left_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_51 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_40 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _13_/Y clkbuf_3_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_182 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_171 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_20 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_62 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_2_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_3_5_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_20_75 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_86 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_66 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_141 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[7] mux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_152 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_163 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_96 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_3_4_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_100 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
