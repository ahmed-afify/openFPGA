* NGSPICE file created from sb_0__1_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__ebufn_1 abstract view
.subckt sky130_fd_sc_hd__ebufn_1 A TE_B Z VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A Y VGND VPWR
.ends

.subckt sb_0__1_ bottom_left_grid_pin_11_ bottom_left_grid_pin_13_ bottom_left_grid_pin_15_
+ bottom_left_grid_pin_1_ bottom_left_grid_pin_3_ bottom_left_grid_pin_5_ bottom_left_grid_pin_7_
+ bottom_left_grid_pin_9_ bottom_right_grid_pin_11_ ccff_head ccff_tail chanx_right_in[0]
+ chanx_right_in[1] chanx_right_in[2] chanx_right_in[3] chanx_right_in[4] chanx_right_in[5]
+ chanx_right_in[6] chanx_right_in[7] chanx_right_in[8] chanx_right_out[0] chanx_right_out[1]
+ chanx_right_out[2] chanx_right_out[3] chanx_right_out[4] chanx_right_out[5] chanx_right_out[6]
+ chanx_right_out[7] chanx_right_out[8] chany_bottom_in[0] chany_bottom_in[1] chany_bottom_in[2]
+ chany_bottom_in[3] chany_bottom_in[4] chany_bottom_in[5] chany_bottom_in[6] chany_bottom_in[7]
+ chany_bottom_in[8] chany_bottom_out[0] chany_bottom_out[1] chany_bottom_out[2] chany_bottom_out[3]
+ chany_bottom_out[4] chany_bottom_out[5] chany_bottom_out[6] chany_bottom_out[7]
+ chany_bottom_out[8] chany_top_in[0] chany_top_in[1] chany_top_in[2] chany_top_in[3]
+ chany_top_in[4] chany_top_in[5] chany_top_in[6] chany_top_in[7] chany_top_in[8]
+ chany_top_out[0] chany_top_out[1] chany_top_out[2] chany_top_out[3] chany_top_out[4]
+ chany_top_out[5] chany_top_out[6] chany_top_out[7] chany_top_out[8] pReset prog_clk
+ right_bottom_grid_pin_12_ right_top_grid_pin_10_ top_left_grid_pin_11_ top_left_grid_pin_13_
+ top_left_grid_pin_15_ top_left_grid_pin_1_ top_left_grid_pin_3_ top_left_grid_pin_5_
+ top_left_grid_pin_7_ top_left_grid_pin_9_ top_right_grid_pin_11_ VPWR VGND
XANTENNA_mux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chanx_right_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _27_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_159 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_100 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_170 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_129 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _27_/HI mux_right_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_57 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_132 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_154 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_11 VGND VPWR sky130_fd_sc_hd__fill_2
X_49_ chany_bottom_in[4] chany_top_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_top_track_0.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_53 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_42 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_9.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _20_/HI mux_bottom_track_9.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_9.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_12.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _22_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_3_ mux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_22_145 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[0] mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_3_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_97 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_145 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_123 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_13_ mux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_108 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_88 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_174 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_36 VGND VPWR sky130_fd_sc_hd__decap_3
X_48_ chany_bottom_in[5] chany_top_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_5_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_6.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_6.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_29_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_35 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_162 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_15_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_143 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_157 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_106 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_32 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_76 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_157 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _16_/HI mux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_8.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_3_69 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[6] mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[3] mux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[3] mux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _15_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_127 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_23 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_142 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[3] mux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_2_123 VGND VPWR sky130_fd_sc_hd__decap_3
X_47_ chany_bottom_in[6] chany_top_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_68 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_79 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_88 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_91 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_10 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_47 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_141 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_65 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_177 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_166 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_67 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[4] mux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xclkbuf_2_1_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_22_136 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_118 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_88 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_180 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_103 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_154 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_49 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_179 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_34 VGND VPWR sky130_fd_sc_hd__fill_2
X_46_ _46_/A chany_top_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_5_ mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_23 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_12 VGND VPWR sky130_fd_sc_hd__decap_8
X_29_ _29_/A chanx_right_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_70 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_79 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_46 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_80 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_91 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_23 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_0.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_6.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _30_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_1_ mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_111 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1 chany_bottom_in[5] mux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_12.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[7]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_103 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_57 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_10.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _21_/HI mux_right_track_10.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_6.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _26_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_17 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_15 VGND VPWR sky130_fd_sc_hd__fill_2
X_45_ _45_/A chany_bottom_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_46 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_4.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_4.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_28_ _28_/A chanx_right_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_16 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_146 VGND VPWR sky130_fd_sc_hd__decap_6
Xmem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ ccff_tail mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N _14_/Y
+ clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_10.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _21_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_116 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__31__A _31_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_15 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chanx_right_in[2]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_29 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_115 VGND VPWR sky130_fd_sc_hd__decap_8
X_44_ chany_top_in[0] chany_bottom_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_top_track_0.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[2] mux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_58 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_36 VGND VPWR sky130_fd_sc_hd__decap_3
X_27_ _27_/HI _27_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_top_track_8.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_111 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_37 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _33_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__34__A _34_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_39 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_166 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_26 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__29__A _29_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_147 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chanx_right_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_128 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_47 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_121 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_1.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xclkbuf_2_0_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__42__A chany_top_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__37__A _37_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_43_ chany_top_in[1] chany_bottom_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[6] mux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_29_6 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_10.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_7_ VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_91 VGND VPWR sky130_fd_sc_hd__fill_1
X_26_ _26_/HI _26_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_28_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_16 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__50__A _50_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_93 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__45__A _45_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_162 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_39 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_103 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_158 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_40 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_73 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_84 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__53__A chany_bottom_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[3]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_128 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_38 VGND VPWR sky130_fd_sc_hd__fill_2
X_42_ chany_top_in[2] chany_bottom_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_7_
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_10.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_bottom_in[8] mux_right_track_10.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__48__A chany_bottom_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
X_25_ _25_/HI _25_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_1_74 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_146 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_2_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_146 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_70 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_11_ mux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_9.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_116 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_116 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_top_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_171 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _45_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_21_152 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chanx_right_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_101 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_112 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_174 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_4.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _25_/HI mux_right_track_4.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_4.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[2] mux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_4.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_4.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_2.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_2.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_2.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_5_115 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_70 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_41_ _41_/A chany_bottom_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_right_track_4.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _25_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_162 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _37_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _16_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_24_ _24_/HI _24_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_31 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_42 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_97 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_73 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_158 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_103 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_30 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_164 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_right_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_21_164 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[4] mux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_19 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_4.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_bottom_in[6] mux_right_track_4.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_127 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_138 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_40_ chany_top_in[4] chany_bottom_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_right_track_2.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_2.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_2.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_2.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_130 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_174 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_3_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_7 VGND VPWR sky130_fd_sc_hd__fill_2
X_23_ _23_/HI _23_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_8.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_21 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_137 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_181 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_95 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_62 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_110 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_151 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_125 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_121 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[8] mux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1 chany_bottom_in[6] mux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_27_83 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_10 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_7_ mux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_1_142 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_96 VGND VPWR sky130_fd_sc_hd__decap_4
X_22_ _22_/HI _22_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_27_7 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_84 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_51 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_105 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_64 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_41 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1 chany_bottom_in[4] mux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_98 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_133 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_181 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_top_track_8.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_40 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_9.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_1_165 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[2] mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[0] mux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[0] mux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_21_ _21_/HI _21_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_top_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1 chanx_right_in[0] mux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _31_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_10 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_right_track_10.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[8]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1_A top_right_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_53 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_105 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_101 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_2.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_2.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[1] mux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1_A bottom_right_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_119 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_right_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_9_ VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_2.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _24_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_65 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_20_ _20_/HI _20_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_bottom_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_12.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_12.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_79 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_53 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_162 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_132 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_173 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_102 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_165 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_10 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_146 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_102 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_128 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_32 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_17.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_7_150 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _34_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_4_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_bottom_in[3] mux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1 chany_bottom_in[1] mux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _18_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_25 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_47 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_6.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_174 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_76 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ mux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_12.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _22_/HI mux_right_track_12.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _41_/A VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_144 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _46_/A VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_9.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chanx_right_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_46 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_125 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_136 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_147 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_66 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_173 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mux_right_track_12.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_14 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_87 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_88 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_0.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_68 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_11 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_15_ mux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_0.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_120 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[1]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_45 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_167 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_123 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_10.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_10.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_10.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_10.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_bottom_in[4] mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_2_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_0.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_bottom_track_1.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_66 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_133 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_158 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_57 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_80 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_1.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_0.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_23 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_6.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_6.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_70 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_157 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_57 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1_A chanx_right_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_179 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_135 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_bottom_track_17.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_109 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_105 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_6.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_8.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_4_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_101 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_145 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_126 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_prog_clk_A prog_clk VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_17 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_57 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_35 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_10.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_10.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_59 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_bottom_in[2] mux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_18_133 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_136 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_38 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_14 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_5_ mux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_1_ VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_57 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__32__A _32_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_113 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_13_15 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_171 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_right_track_6.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _26_/HI mux_right_track_6.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_6.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _54_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_4.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_4.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_4.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_58 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__40__A chany_top_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_145 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_61 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_148 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__35__A _35_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_115 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[0]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_7 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_1_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_93 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_15_ mux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_180 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1 chanx_right_in[1] mux_bottom_track_1.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[7] mux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__43__A chany_top_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_5_50 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__38__A chany_top_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_91 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_146 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_15 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_right_track_2.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_2.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_4.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_4.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_4.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_4.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_157 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_105 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__51__A chany_bottom_in[2] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_38 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_27 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__46__A _46_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_134 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_174 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_163 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_top_track_8.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_1_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_91 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1 chanx_right_in[5] mux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1 chany_bottom_in[2] mux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_5_95 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__54__A _54_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_14.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_14.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_1_ mux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_18 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_158 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_top_track_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N _14_/Y clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_70 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__49__A chany_bottom_in[4] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_125 VGND VPWR sky130_fd_sc_hd__fill_1
Xmem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_139 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_161 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_150 VGND VPWR sky130_fd_sc_hd__fill_2
X_39_ chany_top_in[5] chany_bottom_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_109 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[8]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_4.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_4.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_82 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_131 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_8_73 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_84 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1 chany_bottom_in[0] mux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_71 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_3 VGND VPWR sky130_fd_sc_hd__decap_12
Xmux_bottom_track_1.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_2.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_30 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_8 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_39 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_50 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_2.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _35_/A VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1 top_right_grid_pin_11_ mux_top_track_16.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_60 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_53 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_bottom_track_1.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_15_118 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[5] mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_38_ chany_top_in[6] chany_bottom_out[7] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_bottom_track_9.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_158 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_169 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_4.INVTX1_2_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_150 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_172 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_120 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_13_ mux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_top_track_16.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_4.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_6 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_116 VGND VPWR sky130_fd_sc_hd__fill_2
X_54_ _54_/A chany_top_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_2_32 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _19_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_174 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_52 VGND VPWR sky130_fd_sc_hd__fill_2
X_37_ _37_/A chany_bottom_out[8] VGND VPWR sky130_fd_sc_hd__buf_2
Xmem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_9.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_8.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _17_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_19 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_104 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_51 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[2]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_110 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A
+ mux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_bottom_track_9.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_5_43 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_87 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_40 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_85 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_bottom_in[0] mux_right_track_14.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
X_53_ chany_bottom_in[0] chany_top_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_73 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_99 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1 chanx_right_in[8] mux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_109 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_97 VGND VPWR sky130_fd_sc_hd__fill_2
X_36_ right_top_grid_pin_10_ chanx_right_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_3_ VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_3 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_101 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_14.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_138 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_178 VGND VPWR sky130_fd_sc_hd__fill_2
X_19_ _19_/HI _19_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ mux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_16.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_17_52 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_8.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _50_/A VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_84 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_99 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_63 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_97 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_85 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_27_118 VGND VPWR sky130_fd_sc_hd__fill_2
X_52_ chany_bottom_in[1] chany_top_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_right_track_12.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_bottom_in[7] mux_right_track_12.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_129 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_2.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_151 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_11_21 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_165 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__fill_2
X_35_ _35_/A chanx_right_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_14_176 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_135 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_102 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_9_ mux_top_track_8.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_55 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_86 VGND VPWR sky130_fd_sc_hd__decap_4
X_18_ _18_/HI _18_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_15_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_2.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_2.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[8] VGND
+ VPWR sky130_fd_sc_hd__diode_2
Xmux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_10.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_12.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_12.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_12.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_12.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[4] mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_156 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_167 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_52 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_top_track_0.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_0.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_9.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_54 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_43 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_20 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_track_14.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_130 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_20 VGND VPWR sky130_fd_sc_hd__decap_4
X_51_ chany_bottom_in[2] chany_top_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_17_174 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_163 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
X_34_ _34_/A chanx_right_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_170 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_114 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_67 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_10 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_147 VGND VPWR sky130_fd_sc_hd__fill_2
X_17_ _17_/HI _17_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_6_162 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_21 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_102 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_179 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_6.INVTX1_2_.sky130_fd_sc_hd__inv_1 chany_bottom_in[5] mux_right_track_6.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mux_right_track_12.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_54 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_11 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_top_track_0.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_0.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_0.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_65 VGND VPWR sky130_fd_sc_hd__fill_2
X_50_ _50_/A chany_top_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_178 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_89 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_56 VGND VPWR sky130_fd_sc_hd__decap_3
X_33_ _33_/A chanx_right_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_90 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[5] mux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_22_55 VGND VPWR sky130_fd_sc_hd__fill_2
X_16_ _16_/HI _16_/LO VGND VPWR sky130_fd_sc_hd__conb_1
Xmux_right_track_10.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_10.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_10.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_10.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_6_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_181 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_8.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_8.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_11 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1 bottom_right_grid_pin_11_ mux_bottom_track_1.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_0_147 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_47 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_58 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_69 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[3] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_6 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_23 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_bottom_track_1.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_154 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_37 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_157 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_146 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_113 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_6.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_6.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_6.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_6.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_1.INVTX1_7_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_11_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_124 VGND VPWR sky130_fd_sc_hd__decap_3
X_32_ _32_/A chanx_right_out[4] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_right_track_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_0.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_7 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_bottom_track_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_80 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_23 VGND VPWR sky130_fd_sc_hd__fill_2
X_15_ _15_/HI _15_/LO VGND VPWR sky130_fd_sc_hd__conb_1
XANTENNA_mux_top_track_8.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_67 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_56 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _19_/HI mux_bottom_track_17.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_17.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_0.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_134 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_90 VGND VPWR sky130_fd_sc_hd__decap_6
Xmux_top_track_8.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_8.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_right_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_137 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_26 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_88 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1 bottom_left_grid_pin_9_ mux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[4] mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_122 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[1] mux_right_track_4.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__14__A pReset VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_27 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_11_25 VGND VPWR sky130_fd_sc_hd__fill_2
X_31_ _31_/A chanx_right_out[5] VGND VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_140 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_35 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_106 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_6.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_6.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_6.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_6.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
X_14_ pReset _14_/Y VGND VPWR sky130_fd_sc_hd__inv_8
Xmux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_4.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_4.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_0_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_23 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mux_bottom_track_1.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_1.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_90 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1_A chanx_right_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mux_right_track_2.INVTX1_2_.sky130_fd_sc_hd__inv_1_A right_bottom_grid_pin_12_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__30__A _30_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_134 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_57 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1 chanx_right_in[2] mux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_right_track_2.INVTX1_2_.sky130_fd_sc_hd__inv_1 right_bottom_grid_pin_12_ mux_right_track_2.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1 chanx_right_in[6] mux_top_track_16.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_17_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_167 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_top_track_0.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_0.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_15 VGND VPWR sky130_fd_sc_hd__fill_1
X_30_ _30_/A chanx_right_out[6] VGND VPWR sky130_fd_sc_hd__buf_2
Xmux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[6] mux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_20_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_181 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_14 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_16 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_91 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_158 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_25 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_1.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[0] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_top_track_0.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _15_/HI mux_top_track_0.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_0.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_0_83 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_35 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__33__A _33_/A VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1 chanx_right_in[7] mux_top_track_0.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mem_right_track_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_69 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__decap_4
Xmem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_146 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_4.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_23_105 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_17.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__41__A _41_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_72 VGND VPWR sky130_fd_sc_hd__decap_8
Xmux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_11_ mux_top_track_16.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA__36__A right_top_grid_pin_10_ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_101 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_70 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1 chany_top_in[1] mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_bottom_track_1.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_1.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_0_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_58 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_top_track_16.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__44__A chany_top_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_48 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_16.INVTX1_7_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[6] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[5]
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_158 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_26 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_7_ mux_top_track_0.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xmux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA__39__A chany_top_in[5] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_117 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_top_track_8.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _17_/HI mux_top_track_8.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_top_track_8.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_12.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_154 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_161 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_2.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_2.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_2.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_22_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__52__A chany_bottom_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.INVTX1_6_.sky130_fd_sc_hd__inv_1_A chany_bottom_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA__47__A chany_bottom_in[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_138 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_70 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_9.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_171 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_72 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_83 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_1.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_2_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_29_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_16 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_39 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_93 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_73 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_126 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_181 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mux_right_track_4.INVTX1_1_.sky130_fd_sc_hd__inv_1_A chany_top_in[7] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_170 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mux_top_track_0.INVTX1_2_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_129 VGND VPWR sky130_fd_sc_hd__decap_8
Xmem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_track_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_track_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_bottom_track_9.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_9.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_16.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_30 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_173 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_bottom_track_9.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l1_in_2_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_6_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_39 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_17 VGND VPWR sky130_fd_sc_hd__decap_3
Xmux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[5] mux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_10_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_17 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_3_0_prog_clk clkbuf_2_2_0_prog_clk/A clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_10.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_14.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A _23_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_28 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_29 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_14.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _23_/HI mux_right_track_14.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_14.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _29_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_29_81 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mux_bottom_track_9.INVTX1_7_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_13_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_141 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_bottom_in[1] mux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_right_track_10.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[5] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1_A top_left_grid_pin_5_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_10.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_86 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_10_100 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_177 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_84 VGND VPWR sky130_fd_sc_hd__decap_4
Xmux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_9.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_9.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_5_170 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_top_track_16.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XFILLER_3_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_162 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_7 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1 top_left_grid_pin_3_ mux_top_track_8.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XANTENNA_mux_bottom_track_1.INVTX1_3_.sky130_fd_sc_hd__inv_1_A chanx_right_in[4] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_39 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mux_bottom_track_9.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A _20_/HI
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_bottom_track_17.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
Xmem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_0_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
Xmux_right_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ mux_right_track_12.mux_l2_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_12.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_top_track_8.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_7_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_62 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_top_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_65 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_98 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1 mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ _32_/A VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_6_105 VGND VPWR sky130_fd_sc_hd__fill_1
Xmux_bottom_track_17.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_3_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_1_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_141 VGND VPWR sky130_fd_sc_hd__decap_12
Xmem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_16.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_track_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_1_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_14.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_right_track_14.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_53 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_16.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ mux_top_track_16.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_16.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_top_track_8.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B _14_/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_84 VGND VPWR sky130_fd_sc_hd__fill_2
Xmem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_top_track_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_20_85 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_41 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_2.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 _24_/HI mux_right_track_2.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_right_track_2.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
Xmux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1 chany_top_in[8] mux_right_track_6.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_bottom_track_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.INVTX1_6_.sky130_fd_sc_hd__inv_1_A bottom_left_grid_pin_9_
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_10.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_9.mux_l2_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_173 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_162 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_74 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 mux_bottom_track_17.INVTX1_2_.sky130_fd_sc_hd__inv_1/Y
+ mux_bottom_track_17.mux_l1_in_0_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B mux_bottom_track_17.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_1_0_prog_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1_A mux_right_track_8.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_right_track_6.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[2] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_bottom_track_17.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_165 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_132 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_114 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_136 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1 _18_/HI mux_bottom_track_1.mux_l1_in_2_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/TE_B
+ mux_bottom_track_1.mux_l1_in_2_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_9.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_9.INVTX1_5_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/A
+ mux_top_track_0.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_top_track_0.tap_buf4_0_.sky130_fd_sc_hd__inv_1/A
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mux_bottom_track_9.INVTX1_0_.sky130_fd_sc_hd__inv_1_A chany_top_in[1] VGND
+ VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_8.mux_l2_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.mux_l1_in_1_.TGATE_2_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_75 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_bottom_track_17.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_bottom_track_17.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mux_top_track_16.mux_l1_in_0_.TGATE_0_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_16.INVTX1_0_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_30 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mux_top_track_8.mux_l1_in_1_.TGATE_1_.sky130_fd_sc_hd__ebufn_1_A mux_top_track_8.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__diode_2
Xmem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_bottom_track_9.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ _14_/Y clkbuf_2_3_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_bottom_track_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_6 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1 mux_right_track_12.INVTX1_1_.sky130_fd_sc_hd__inv_1/Y
+ mux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/TE_B mux_right_track_12.mux_l1_in_0_.TGATE_1_.sky130_fd_sc_hd__ebufn_1/Z
+ VGND VPWR sky130_fd_sc_hd__ebufn_1
XANTENNA_mem_right_track_8.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_track_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_top_track_8.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_116 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_2_0_prog_clk clkbuf_2_2_0_prog_clk/A clkbuf_2_2_0_prog_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_right_track_12.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_97 VGND VPWR sky130_fd_sc_hd__fill_2
Xmux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1 chanx_right_in[7] mux_bottom_track_1.INVTX1_4_.sky130_fd_sc_hd__inv_1/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_42 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_top_track_8.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ VGND VPWR sky130_fd_sc_hd__diode_2
.ends
