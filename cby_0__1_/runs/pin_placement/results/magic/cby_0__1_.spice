* NGSPICE file created from cby_0__1_.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrbp_1 abstract view
.subckt sky130_fd_sc_hd__dfrbp_1 D Q Q_N RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

.subckt cby_0__1_ chany_out_7_ chany_in_6_ chany_in_2_ chany_out_15_ chany_in_1_ left_grid_pin_8_
+ left_grid_pin_12_ chany_in_14_ chany_out_9_ chany_in_15_ chany_out_6_ chany_in_0_
+ left_grid_pin_14_ chany_in_4_ chany_in_3_ chany_out_1_ chany_out_16_ chany_out_11_
+ chany_out_12_ chany_out_0_ right_grid_pin_7_ chany_in_8_ chany_in_9_ right_grid_pin_3_
+ chany_in_16_ left_grid_pin_0_ chany_in_12_ prog_clk chany_in_13_ chany_out_17_ left_grid_pin_4_
+ chany_out_4_ chany_in_11_ chany_in_17_ chany_out_14_ ccff_tail ccff_head pReset
+ left_grid_pin_10_ left_grid_pin_6_ left_grid_pin_2_ chany_out_13_ chany_out_3_ chany_in_5_
+ chany_out_8_ chany_out_5_ chany_in_10_ chany_in_7_ chany_out_2_ chany_out_10_
XFILLER_22_111 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_30 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_1
Xmem_right_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_32 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ _09_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_5_162 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_184 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_86 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_53 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_8
Xmem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_132 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_154 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_11 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_55 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_66 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_1_0_prog_clk_A clkbuf_2_1_0_prog_clk/A PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_54 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_32 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_172 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_3 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_56 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_42 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_98 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XPHY_170 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_123 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_142 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_20 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_123 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_13 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_46 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_196 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _11_/VGND _11_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_98 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_87 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_32 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_21 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_107 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_42 _20_/VGND _13_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_184 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_110 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_171 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_179 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_135 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_87 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XPHY_160 _20_/VGND _13_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_154 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_179 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_135 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_32 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_179 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_146 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_106 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ _11_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_183 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_105 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_112 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_123 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_145 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_3 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_4
Xmem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_right_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_29_119 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_0_0_prog_clk_A clkbuf_0_prog_clk/X PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_80 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_141 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_196 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_22 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_45 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_12 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XPHY_172 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_169 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_147 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_103 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XPHY_161 _15_/VGND _13_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_150 _18_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_2_1_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_1_0_prog_clk/X PHY_31/VGND
+ PHY_33/VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_26_44 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_114 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_118 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_191 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_59 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_195 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_139 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_154 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XANTENNA__12__A chany_in_11_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_12 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_3 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_9 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ _09_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_22 _20_/VGND _13_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_11 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_15 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_164 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_131 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_120 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XANTENNA__20__A chany_in_2_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_123 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_57 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_4
XPHY_173 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_159 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_115 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_6
XPHY_162 _15_/VGND _13_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_151 _18_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_140 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_3 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_181 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_56 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XANTENNA__15__A chany_in_14_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_38 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_36 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
Xmem_right_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ ccff_tail mem_right_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset
+ clkbuf_2_0_0_prog_clk/X _09_/VGND _00_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_8_152 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_111 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_166 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_15 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_59 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
Xmem_right_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA__23__A chany_in_5_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_29_45 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_154 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__18__A chany_in_17_ _11_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_58 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_36 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_176 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_91 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_135 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__diode_2
XPHY_174 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_163 _15_/VGND _13_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_152 _18_/VGND _26_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_141 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_130 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_193 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_160 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_105 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_70 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_68 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_24 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_182 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_160 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_127 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__26__A chany_in_8_ _18_/VGND _26_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_15 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_123 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_93 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_18 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ _18_/VGND _18_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_36 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_3 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_4
X_27_ chany_in_9_ chany_out_9_ _15_/VGND _13_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_72 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_57 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_166 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_48 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_15 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_111 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_180 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_47 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_147 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_175 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_164 _15_/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_153 _18_/VGND _26_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_142 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_131 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_120 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_172 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_139 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XPHY_0 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_82 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_139 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_91 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_154 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_2_0_0_prog_clk clkbuf_2_1_0_prog_clk/A clkbuf_2_0_0_prog_clk/X PHY_19/VGND
+ PHY_21/VPWR sky130_fd_sc_hd__clkbuf_1
Xmem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_2_105 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_116 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
Xmem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_18_48 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_15 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_4
Xmem_right_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_3 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_80 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
X_26_ chany_in_8_ chany_out_8_ _20_/VGND _26_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_27 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_84 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_62 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_51 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_178 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_123 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_9 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_93 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_159 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_49 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_16 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
X_09_ _09_/HI right_grid_pin_3_ _09_/VGND _00_/VPWR sky130_fd_sc_hd__conb_1
XPHY_165 _15_/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_59 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_26 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_15 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XPHY_154 _18_/VGND _26_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_181 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XPHY_143 _11_/VGND _11_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XPHY_132 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_121 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_126 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XPHY_110 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_170 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XPHY_1 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_15 _18_/VGND _18_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_184 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_94 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_80 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_151 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_28 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_84 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_16 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_128 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
X_25_ chany_in_7_ chany_out_7_ _15_/VGND _13_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_29_26 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_96 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_83 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_19 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_168 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_135 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_70 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_2_0_prog_clk_A clkbuf_2_3_0_prog_clk/A PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
X_08_ _08_/HI left_grid_pin_0_ _08_/VGND _07_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_31_38 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_105 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XPHY_100 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 _15_/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_155 _20_/VGND _26_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_193 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_4
XPHY_144 _11_/VGND _11_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_82 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_60 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_1
XPHY_133 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_122 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_182 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_1
XPHY_111 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_196 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_152 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_119 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_40 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_62 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_93 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_71 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_134 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_115 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ _00_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_9 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_184 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_93 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
X_24_ chany_in_6_ chany_out_6_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_29_38 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_16 _20_/VGND _13_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_3 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_19_82 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
X_07_ _07_/HI left_grid_pin_10_ _09_/VGND _07_/VPWR sky130_fd_sc_hd__conb_1
XPHY_167 _22_/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_156 _20_/VGND _26_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_145 _11_/VGND _11_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_134 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_123 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_117 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_6
XPHY_112 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_101 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_197 _15_/VGND _13_/VPWR sky130_fd_sc_hd__fill_1
XPHY_3 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_52 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_164 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_131 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_93 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_197 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_146 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_119 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_62 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_196 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_163 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_29 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_7 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
X_23_ chany_in_5_ chany_out_5_ _15_/VGND _13_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_10 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_195 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_3 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_8
X_06_ _06_/HI left_grid_pin_12_ _09_/VGND _00_/VPWR sky130_fd_sc_hd__conb_1
XPHY_168 _22_/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_157 _20_/VGND _26_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_146 _11_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_135 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_62 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XPHY_124 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_102 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_176 _15_/VGND _13_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_154 _15_/VGND _13_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_121 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_184 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_162 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XPHY_4 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_176 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_clkbuf_1_1_0_prog_clk_A clkbuf_0_prog_clk/X PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_62 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_154 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_106 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_109 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_32 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_41 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_120 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
X_22_ chany_in_4_ chany_out_4_ _22_/VGND _22_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_55 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_105 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_171 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_127 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_62 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_160 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_3 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
X_05_ _05_/HI left_grid_pin_14_ _09_/VGND _00_/VPWR sky130_fd_sc_hd__conb_1
Xmem_right_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_169 _22_/VGND _22_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_158 _20_/VGND _13_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_147 _11_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_174 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_141 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XPHY_136 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_85 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_74 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_52 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XPHY_125 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_103 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_133 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_196 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XPHY_5 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_170 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_62 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_129 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_44 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__diode_2
X_21_ chany_in_3_ chany_out_3_ _15_/VGND _13_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_right_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_117 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_139 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_117 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_87 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_32 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
X_04_ _04_/HI left_grid_pin_2_ _08_/VGND _07_/VPWR sky130_fd_sc_hd__conb_1
XPHY_159 _20_/VGND _13_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_148 _11_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_197 _11_/VGND _11_/VPWR sky130_fd_sc_hd__fill_1
XPHY_137 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_126 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_104 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_145 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_8
XPHY_6 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_11 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_66 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_3 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_156 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_123 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_75 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_101 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_105 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_182 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_119 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_74 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_56 _00_/VGND _00_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_196 _00_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_155 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_3 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
X_20_ chany_in_2_ chany_out_2_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_1_68 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ _00_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_129 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_53 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_prog_clk prog_clk clkbuf_0_prog_clk/X PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_10_44 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_184 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_86 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_151 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
X_03_ _03_/HI left_grid_pin_4_ _09_/VGND _00_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_187 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_184 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XPHY_116 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_105 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_right_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_149 _18_/VGND _18_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_154 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XPHY_138 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_127 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_110 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XPHY_7 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_3 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_6
Xmem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X _08_/VGND _07_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_56 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_16_87 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_32 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_21 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_179 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_135 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_27_86 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_88 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_55 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_167 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_123 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_32 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_14 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_56 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_196 _18_/VGND _26_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_21 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_196 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
X_02_ _02_/HI left_grid_pin_6_ _09_/VGND _00_/VPWR sky130_fd_sc_hd__conb_1
XFILLER_24_166 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_8
XPHY_139 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_128 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_106 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_3 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_166 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XPHY_8 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_114 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_147 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_32 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_162 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_184 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_98 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_21 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _09_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_154 _00_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_45 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_12 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_179 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_135 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_44 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_59 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_66 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
Xmem_right_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X _09_/VGND _07_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_33_156 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
X_01_ _01_/HI left_grid_pin_8_ _09_/VGND _07_/VPWR sky130_fd_sc_hd__conb_1
XANTENNA__10__A chany_in_0_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_89 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_56 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_23 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XPHY_129 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_107 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_123 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X _00_/VGND _00_/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_9 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_44 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_181 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_2_3_0_prog_clk_A clkbuf_2_3_0_prog_clk/A PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_196 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_33 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_15 _00_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_59 _00_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_133 _00_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_188 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_147 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_180 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XANTENNA__13__A chany_in_12_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_56 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_23 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_3 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_110 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_168 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_154 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_143 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_8
X_00_ _00_/HI right_grid_pin_7_ _00_/VGND _00_/VPWR sky130_fd_sc_hd__conb_1
XPHY_119 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_108 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_ipin_6.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_135 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_15 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_59 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_127 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_56 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__21__A chany_in_3_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_193 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_68 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_57 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_105 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_3 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_182 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_1
XANTENNA__16__A chany_in_15_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_45 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_159 _08_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_70 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_68 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_clkbuf_0_prog_clk_A prog_clk PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D ccff_head _09_/VGND
+ _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_90 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_39 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_24 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_15 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_125 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__24__A chany_in_6_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XPHY_109 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_93 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__19__A chany_in_1_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_147 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_32_68 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
Xmem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_right_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_3 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_121 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_57 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_179 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA__27__A chany_in_9_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_59 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_82 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _09_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_123 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_101 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_137 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XPHY_90 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_181 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_15 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_159 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_left_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_118 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_181 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_151 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_15 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_91 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_184 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_162 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_166 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_60 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_93 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_16 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_15 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_94 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_135 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_59 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_15 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_3 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_149 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_190 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_84 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_8
XPHY_80 _09_/VGND _00_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_91 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_193 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_105 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_27 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_9 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_15 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_193 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_196 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_123 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_15 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_19 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X _00_/VGND _00_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_4_137 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_92 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_80 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_195 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_40 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_62 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_93 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_147 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_106 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XPHY_70 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_81 _09_/VGND _00_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_92 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_117 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_52 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_109 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_72 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_27 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_197 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_93 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_120 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_113 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_135 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_105 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_84 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_149 _00_/VGND _00_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_3 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_108 _08_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_171 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_52 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_93 _15_/VGND _13_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_61 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_159 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_28 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_19 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_118 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XPHY_60 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_60 _11_/VGND _18_/VPWR sky130_fd_sc_hd__fill_1
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XPHY_71 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_82 _09_/VGND _00_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_93 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_mem_right_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_129 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_184 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_62 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_40 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_151 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_154 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_143 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_29 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_110 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_147 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_50 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_right_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_93 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_190 _20_/VGND _13_/VPWR sky130_fd_sc_hd__fill_2
Xmem_right_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_73 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XPHY_61 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_3
XPHY_50 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_127 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XPHY_72 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_83 _00_/VGND _00_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_94 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_174 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_141 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_171 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_32 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_196 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_52 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_3 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_166 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_159 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_62 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_94 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_184 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_187 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_6.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_40 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_85 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_139 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XPHY_62 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XPHY_51 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_62 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_40 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_55 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_44 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_8
XPHY_73 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_84 _00_/VGND _00_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_95 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_197 _22_/VGND _22_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_175 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_131 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_197 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_3 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_178 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_123 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_101 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_32 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
X_19_ chany_in_1_ chany_out_1_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__buf_2
Xmem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_3_152 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_163 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_11 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_66 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_3 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_74 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_20 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_6
Xmem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 ccff_head mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_left_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N pReset clkbuf_2_0_0_prog_clk/X
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_7.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XPHY_63 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XPHY_52 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_74 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_41 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_30 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_3
XPHY_74 _08_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_85 _00_/VGND _00_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_96 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_154 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_184 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_143 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_110 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_154 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_76 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_75 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_20 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_106 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_117 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_180 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_183 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_44 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
X_18_ chany_in_17_ chany_out_17_ _18_/VGND _18_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_4_109 _00_/VGND _00_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_63 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_42 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_175 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_197 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_56 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_65 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_32 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_86 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XPHY_64 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XPHY_53 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_86 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_42 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XPHY_31 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_3
XPHY_75 _08_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_86 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_97 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_20 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_166 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_196 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_163 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_155 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_66 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_55 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_11 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_122 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_114 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_87 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_32 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_158 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_56 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_3 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
X_17_ chany_in_16_ chany_out_16_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_195 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_75 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_168 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_7.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_7.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X _00_/VGND _00_/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X _09_/VGND _07_/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_32 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_194 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
Xmem_right_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_1.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XPHY_65 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_3
XPHY_54 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_98 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_43 PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XPHY_32 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_3
XPHY_21 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XPHY_76 _08_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_10 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XPHY_87 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_167 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_123 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_134 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_160 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_44 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_148 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_8
X_16_ chany_in_15_ chany_out_15_ _15_/VGND _13_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_26_3 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_181 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_152 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_87 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_32 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_55 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_32 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_125 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_99 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_184 _20_/VGND _13_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XPHY_66 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_3
XPHY_55 _18_/VGND _26_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_154 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_44 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_11 _11_/VGND _18_/VPWR sky130_fd_sc_hd__fill_1
XPHY_44 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XPHY_33 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_3
XPHY_22 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_3
XPHY_77 _09_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_88 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_11 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XPHY_99 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_110 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_59 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_190 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_179 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_146 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XANTENNA__11__A chany_in_10_ PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_116 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_109 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
X_15_ chany_in_14_ chany_out_14_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_19_3 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_193 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_67 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_44 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_101 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_123 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_156 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_167 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_189 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_44 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_137 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_15 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_59 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_67 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_23 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_8
Xmem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_14_57 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_4
XPHY_12 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
Xmem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_left_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_67 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_3
XANTENNA__14__A chany_in_13_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__diode_2
XPHY_56 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_56 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_4
XPHY_45 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XPHY_34 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__dfrbp_1
XPHY_23 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_3
XPHY_78 _09_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_89 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X _11_/VGND _18_/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_191 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_184 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_106 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_132 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_154 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_15 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__fill_2
X_14_ chany_in_13_ chany_out_13_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_33_56 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_6
XANTENNA__22__A chany_in_4_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_3 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA__17__A chany_in_16_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_56 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_23 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_3.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_149 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_69 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_153 _20_/VGND _13_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_90 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XPHY_57 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_178 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_46 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_3
XPHY_35 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XPHY_24 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_17 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XPHY_68 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_79 _09_/VGND _07_/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_13 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_167 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_123 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XANTENNA__25__A chany_in_7_ _20_/VGND _13_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_59 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_15 PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_118 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ _00_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_130 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_2_0_0_prog_clk_A clkbuf_2_1_0_prog_clk/A PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_196 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_151 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
X_13_ chany_in_12_ chany_out_12_ _15_/VGND _13_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_3_114 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_3 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_180 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_68 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_106 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_94 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_70 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_90 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_26 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_15 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_47 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_176 _20_/VGND _13_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_60 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_93 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XPHY_58 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_14 _11_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XPHY_47 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XPHY_36 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XPHY_25 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_3
XPHY_69 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_14 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_105 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_135 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_29 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
Xmem_right_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X _09_/VGND _00_/VPWR sky130_fd_sc_hd__dfrbp_1
Xmem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_2.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_0.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_142 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_164 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_15 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
X_12_ chany_in_11_ chany_out_11_ _15_/VGND _22_/VPWR sky130_fd_sc_hd__buf_2
XANTENNA_mem_right_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_59 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_1.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_148 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_5.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_4.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_192 _09_/VGND _07_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_3 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_7.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ _09_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_118 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_59 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_15 _15_/VGND _13_/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XPHY_59 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_3
XPHY_48 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_3
XPHY_37 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_3
XPHY_26 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XPHY_15 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_117 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_91 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_147 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_114 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_2.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_194 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_80 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_109 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_150 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_51 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_62 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_95 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_110 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_154 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
X_11_ chany_in_10_ chany_out_10_ _11_/VGND _11_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_12_93 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_60 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_197 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_15 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_63 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_30 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_15 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_2.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_156 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_123 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_1_1_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_3_0_prog_clk/A PHY_27/VGND PHY_26/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_93 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_2
XPHY_49 _11_/VGND _11_/VPWR sky130_fd_sc_hd__decap_3
XPHY_38 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_3
XPHY_27 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
Xmem_right_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_0_0_prog_clk/X PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_6_84 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_8
XPHY_16 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_129 _22_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_159 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_184 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_151 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
Xmem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_left_ipin_1.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_7_3 PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_6
XANTENNA_mem_right_ipin_3.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_3.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_184 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_28 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
X_10_ chany_in_0_ chany_out_0_ _15_/VGND _13_/VPWR sky130_fd_sc_hd__buf_2
XFILLER_10_154 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_110 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_136 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_19 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q mem_right_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_17_17 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_27 _22_/VGND PHY_66/VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_3_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_3_0_prog_clk/X PHY_35/VGND
+ PHY_33/VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_40 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_62 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_93 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_4.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_left_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_3 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_29 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_179 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_168 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_135 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_92 _20_/VGND _13_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_190 _20_/VGND _26_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_105 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_28 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_3.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XPHY_17 PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_171 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_39 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_82 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_93 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_196 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_123 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_84 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_40 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_148 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_4.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_4.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/Q
+ _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_170 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_118 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_140 _09_/VGND _07_/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_0.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_1_0_prog_clk/X
+ PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_74 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_83 PHY_39/VGND PHY_37/VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_3 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_147 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_103 _20_/VGND _13_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_84 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_4
XANTENNA_mem_right_ipin_0.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_117 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_18 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_106 PHY_35/VGND PHY_37/VPWR sky130_fd_sc_hd__fill_2
XPHY_29 PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_5.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_5.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q
+ _09_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XPHY_18 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XANTENNA_mem_right_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_150 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_62 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_175 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_183 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ mem_right_ipin_5.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_2_0_prog_clk/X PHY_19/VGND PHY_17/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_22_197 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_175 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_142 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_4.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ _09_/VGND _00_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_87 _09_/VGND _00_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_168 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1 mem_right_ipin_2.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_2.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_3_0_prog_clk/X PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__dfrbp_1
XFILLER_12_52 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_105 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_182 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_62 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_44 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_12
Xmem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1 mem_left_ipin_1.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/Q
+ mem_right_ipin_0.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1/D mem_right_ipin_0.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1/Q_N
+ pReset clkbuf_2_1_0_prog_clk/X PHY_31/VGND PHY_26/VPWR sky130_fd_sc_hd__dfrbp_1
XANTENNA_mem_right_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_5.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_94/VGND PHY_17/VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_86 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_72 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_32 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_129 _18_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XPHY_19 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_62 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_51 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_184 _11_/VGND _18_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_3.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_3_0_prog_clk/X
+ PHY_43/VGND PHY_45/VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_74 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_41 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_121 _15_/VGND _22_/VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_195 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0_0_prog_clk clkbuf_0_prog_clk/X clkbuf_2_1_0_prog_clk/A PHY_31/VGND PHY_26/VPWR
+ sky130_fd_sc_hd__clkbuf_1
XANTENNA_mem_right_ipin_5.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ _09_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_4.sc_dff_compact_1_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_2_0_prog_clk/X
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_154 PHY_47/VGND PHY_45/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_6.sc_dff_compact_2_.sky130_fd_sc_hd__dfrbp_1/D
+ PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_6.sc_dff_compact_3_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_110 PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__fill_2
XANTENNA_mem_right_ipin_7.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ _08_/VGND _07_/VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_55 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_114 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_20 PHY_27/VGND PHY_25/VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_135 PHY_23/VGND PHY_21/VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_3 _00_/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_109 _09_/VGND _00_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_74 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_41 PHY_47/VGND _11_/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_left_ipin_0.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_CLK clkbuf_2_0_0_prog_clk/X
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_56 _08_/VGND PHY_0/VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_98 PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__decap_8
XANTENNA_mem_right_ipin_7.sc_dff_compact_0_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_19/VGND PHY_21/VPWR sky130_fd_sc_hd__diode_2
XANTENNA_mem_right_ipin_1.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_95 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_84 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_62 _20_/VGND _13_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_97 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_6.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_D mem_right_ipin_6.sc_dff_compact_4_.sky130_fd_sc_hd__dfrbp_1/Q
+ PHY_23/VGND PHY_25/VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_2_0_prog_clk clkbuf_2_3_0_prog_clk/A clkbuf_2_2_0_prog_clk/X PHY_19/VGND
+ PHY_21/VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_19_182 PHY_39/VGND PHY_40/VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_3 PHY_43/VGND PHY_40/VPWR sky130_fd_sc_hd__decap_12
XANTENNA_mem_right_ipin_3.sc_dff_compact_5_.sky130_fd_sc_hd__dfrbp_1_RESET_B pReset
+ PHY_27/VGND PHY_26/VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_44 PHY_94/VGND PHY_13/VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_74 _15_/VGND _22_/VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_196 _11_/VGND _18_/VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_86 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_53 PHY_31/VGND PHY_33/VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_130 PHY_35/VGND PHY_33/VPWR sky130_fd_sc_hd__decap_12
.ends
