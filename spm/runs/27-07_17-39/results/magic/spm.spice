* NGSPICE file created from spm.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 D Q RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_4 abstract view
.subckt sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B X VGND VPWR
.ends

.subckt spm clk p rst x[0] x[10] x[11] x[12] x[13] x[14] x[15] x[16] x[17] x[18] x[19]
+ x[1] x[20] x[21] x[22] x[23] x[24] x[25] x[26] x[27] x[28] x[29] x[2] x[30] x[31]
+ x[3] x[4] x[5] x[6] x[7] x[8] x[9] y VPWR VGND
XFILLER_39_211 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__666__D _666_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_144 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_133 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__510__A1 _506_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__510__B2 _507_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_501_ _508_/A x[8] _502_/A VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_26_41 VGND VPWR sky130_fd_sc_hd__fill_2
X_432_ _428_/X _432_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_13_111 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_40 VGND VPWR sky130_fd_sc_hd__fill_1
X_363_ _363_/A _363_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__568__A1 _564_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__568__B2 _565_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__670__RESET_B _401_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_236 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_54 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__612__A2_N _608_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_62 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__627__A2_N _622_/Y VGND VPWR sky130_fd_sc_hd__diode_2
X_415_ _414_/A _415_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_346_ _624_/A x[29] _347_/A VGND VPWR sky130_fd_sc_hd__and2_4
XANTENNA__656__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_140 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_173 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_184 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__679__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_165 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_143 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_132 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__468__B1 _466_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__640__B1 _697_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__504__A2_N _500_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_33 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_44 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_1_0_clk clkbuf_2_0_0_clk/X _670_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__519__A2_N _514_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__674__D _556_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__702__RESET_B _361_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_680_ _680_/D _565_/A _389_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_18_64 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_86 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_231 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__490__A2_N _486_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__402__A _398_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__669__D _669_/D VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__604__B1 _600_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_128 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_194 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__598__A1_N _593_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__583__A1_N _578_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_43 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_109 VGND VPWR sky130_fd_sc_hd__fill_2
X_594_ _688_/Q _594_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_663_ _663_/D _663_/Q _411_/X _663_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_6_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_78 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__695__RESET_B _370_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_142 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_219 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_208 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__335__A2_N _637_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_109 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_42 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_197 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_54 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__475__A1_N _470_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_134 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_101 VGND VPWR sky130_fd_sc_hd__fill_2
X_646_ _455_/X _438_/A _431_/X _663_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_577_ _577_/A _575_/X _680_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XPHY_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_112 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__682__D _584_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__510__A2 _507_/Y VGND VPWR sky130_fd_sc_hd__diode_2
X_500_ _500_/A _500_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__500__A _500_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_75 VGND VPWR sky130_fd_sc_hd__fill_2
X_431_ _428_/X _431_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_362_ _363_/A _362_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_13_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_134 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_63 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_24 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__410__A _422_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_215 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_204 VGND VPWR sky130_fd_sc_hd__fill_2
X_629_ _629_/A _629_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__568__A2 _565_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__677__D _677_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_218 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_207 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_108 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_115 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_159 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_215 VGND VPWR sky130_fd_sc_hd__decap_3
X_414_ _414_/A _414_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_345_ _704_/Q _345_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__405__A _409_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_87 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__468__B2 _467_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_14 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__640__B2 _700_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__640__A1 _636_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__649__RESET_B _427_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_56 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_67 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_89 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__690__D _613_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__646__CLK _663_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_86 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_225 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_236 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_8 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_184 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__604__B2 _690_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__604__A1 _600_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__685__D _598_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__669__CLK _698_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__540__B1 _541_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_77 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_88 VGND VPWR sky130_fd_sc_hd__decap_4
X_662_ _512_/X _500_/A _412_/X _673_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_28_151 VGND VPWR sky130_fd_sc_hd__fill_2
X_593_ _685_/Q _593_/Y VGND VPWR sky130_fd_sc_hd__inv_8
Xclkbuf_3_0_0_clk clkbuf_2_0_0_clk/X _663_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__413__A _414_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_132 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__598__B1 _596_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__664__RESET_B _409_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_162 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_187 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_165 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_132 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_231 VGND VPWR sky130_fd_sc_hd__fill_2
X_645_ _645_/D _645_/Q _432_/X _663_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_31_168 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_157 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_113 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__408__A _409_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_576_ _571_/Y _572_/Y _577_/A _575_/X _679_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_16_143 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__504__B1 _502_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_202 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_102 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_32 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_21 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_87 VGND VPWR sky130_fd_sc_hd__fill_1
X_361_ _363_/A _361_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_128 VGND VPWR sky130_fd_sc_hd__fill_2
X_430_ _428_/X _430_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_36_238 VGND VPWR sky130_fd_sc_hd__decap_12
X_628_ _628_/A _628_/B _628_/X VGND VPWR sky130_fd_sc_hd__xor2_4
X_559_ _559_/A x[16] _559_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_8_172 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_190 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__601__A _690_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__349__A2_N _345_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_249 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_205 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__693__D _693_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_67 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_53 VGND VPWR sky130_fd_sc_hd__decap_4
X_413_ _414_/A _413_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_18_238 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_241 VGND VPWR sky130_fd_sc_hd__decap_3
X_344_ _701_/Q _344_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__421__A _420_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_153 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_197 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__688__D _606_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_208 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__506__A _661_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_44 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_33 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_101 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__689__RESET_B _378_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__640__A2 _637_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__416__A _422_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_43 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_32 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_108 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__604__A2 _601_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_207 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__540__B2 _539_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_23 VGND VPWR sky130_fd_sc_hd__fill_2
X_661_ _511_/X _661_/Q _413_/X _673_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_29_87 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_141 VGND VPWR sky130_fd_sc_hd__fill_2
X_592_ _592_/A _590_/X _592_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_6_36 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__598__B2 _597_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_174 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__696__D _696_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_158 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_66 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__514__A _514_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_575_ _571_/Y _572_/Y _679_/Q _572_/A _575_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_644_ _448_/Y _352_/A _433_/X _698_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_16_122 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__659__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_147 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__424__A _423_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_188 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_199 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__504__B2 _503_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_236 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_191 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_169 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__509__A _508_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_32 VGND VPWR sky130_fd_sc_hd__decap_8
X_360_ _372_/A _363_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_13_158 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_191 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_15 VGND VPWR sky130_fd_sc_hd__decap_6
X_558_ _558_/A _558_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_627_ _621_/Y _622_/Y _628_/A _628_/B _693_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XANTENNA__419__A _420_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_489_ _485_/Y _486_/Y _485_/A _486_/A _489_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_8_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_180 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__489__B1 _485_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_217 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_106 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_206 VGND VPWR sky130_fd_sc_hd__decap_4
X_412_ _414_/A _412_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_343_ _340_/X _343_/B _700_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_38_7 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_132 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__634__B1 _635_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_56 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__522__A _668_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__658__RESET_B _417_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__432__A _428_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__607__A _607_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__699__D _342_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_223 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__517__A _517_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__692__CLK _692_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_249 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_245 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__427__A _423_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_131 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_175 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__337__A _337_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_33 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_11 VGND VPWR sky130_fd_sc_hd__fill_2
X_660_ _505_/X _660_/Q _414_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_28_186 VGND VPWR sky130_fd_sc_hd__fill_2
X_591_ _585_/Y _586_/Y _592_/A _590_/X _591_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_3_230 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_90 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__673__RESET_B _398_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__620__A _617_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_126 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_189 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_79 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__530__A _544_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_244 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_222 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_211 VGND VPWR sky130_fd_sc_hd__fill_2
X_574_ _574_/A _577_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_643_ _447_/X _643_/Q _434_/X _698_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_16_178 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__440__A _479_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__615__A _615_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_80 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__350__A _350_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_45 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_115 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_44 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_119 VGND VPWR sky130_fd_sc_hd__decap_3
X_488_ _487_/X _488_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_557_ _675_/Q _557_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_626_ _621_/Y _622_/Y _693_/Q _622_/A _628_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XANTENNA__435__A _366_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__489__A1 _485_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__489__B2 _486_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_240 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__345__A _704_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_58 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__649__CLK _663_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_99 VGND VPWR sky130_fd_sc_hd__fill_2
X_342_ _337_/Y _338_/Y _340_/X _343_/B _342_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_411_ _414_/A _411_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_177 VGND VPWR sky130_fd_sc_hd__fill_2
X_609_ _616_/A x[23] _610_/A VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_4_81 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__634__B2 _635_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_169 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_136 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_37 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_232 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__561__B1 _675_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__698__RESET_B _367_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__623__A y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_13 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_68 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_78 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_23 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__533__A1_N _528_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_250 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_82 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__525__B1 _665_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__353__A _479_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_56 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_154 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__528__A _528_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_590_ _585_/Y _586_/Y _683_/Q _686_/Q _590_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_3_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_179 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__438__A _438_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__642__RESET_B _435_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_0_clk_A clk VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__620__B _620_/B VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__682__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_13 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_58 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_57 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__530__B x[12] VGND VPWR sky130_fd_sc_hd__diode_2
X_642_ _642_/D p _435_/X _670_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_31_105 VGND VPWR sky130_fd_sc_hd__fill_2
X_573_ _559_/A x[18] _574_/A VGND VPWR sky130_fd_sc_hd__and2_4
XPHY_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_249 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__350__B _348_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__631__A _624_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_13 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_138 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_127 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_56 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_160 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_28 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__541__A _541_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_219 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_208 VGND VPWR sky130_fd_sc_hd__decap_6
X_625_ _625_/A _628_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_487_ _508_/A x[6] _487_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_556_ _553_/X _554_/X _556_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_16_90 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__489__A2 _486_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_197 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__451__A _472_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__361__A _363_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_45 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_12 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_6_0_clk_A clkbuf_3_6_0_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_233 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_241 VGND VPWR sky130_fd_sc_hd__decap_12
X_410_ _422_/A _414_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_341_ _337_/Y _338_/Y _337_/A _338_/A _343_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XANTENNA__536__A _536_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_189 VGND VPWR sky130_fd_sc_hd__fill_2
X_608_ _692_/Q _608_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__446__A _479_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_539_ _535_/Y _536_/Y _669_/Q _536_/A _539_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_104 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__561__A1 _557_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__561__B2 _558_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__667__RESET_B _406_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__562__A2_N _558_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_36 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_229 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_236 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_2_3_0_clk_A clkbuf_2_3_0_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_155 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__525__B2 _668_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__525__A1 _521_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__353__B x[30] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_111 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__461__B1 _459_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__544__A _544_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__454__A2_N _450_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_166 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_177 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_188 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_191 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__682__RESET_B _387_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_169 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_136 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__443__B1 _437_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__629__A _629_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_139 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__547__A1_N _542_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__364__A _363_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_641_ _444_/X _437_/A _436_/X _670_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_572_ _572_/A _572_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_31_117 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_125 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_147 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__449__A _645_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_1_0_0_clk_A clkbuf_0_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_180 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__631__B x[26] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__359__A rst VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_2_0_clk_A clkbuf_3_3_0_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_25 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__541__B _539_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_150 VGND VPWR sky130_fd_sc_hd__decap_4
X_555_ _549_/Y _550_/Y _553_/X _554_/X _555_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_624_ _624_/A x[25] _625_/A VGND VPWR sky130_fd_sc_hd__and2_4
X_486_ _486_/A _486_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_194 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_80 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__672__CLK _673_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_165 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__451__B x[1] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_209 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_68 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_340_ _339_/X _340_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__552__A _559_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__702__D _702_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_157 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__695__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
X_607_ _607_/A _607_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_32_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_90 VGND VPWR sky130_fd_sc_hd__fill_2
X_538_ _537_/X _541_/A VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__446__B x[31] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__462__A _459_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_469_ _466_/X _467_/X _650_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XANTENNA__619__B1 _617_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_72 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_61 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_50 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__637__A _700_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_37 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__372__A _372_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_223 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_245 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__561__A2 _558_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__457__A _650_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_226 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_36 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__367__A _369_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_167 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_123 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_51 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__525__A2 _522_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_145 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__461__B2 _460_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__560__A _559_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__544__B x[14] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_222 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_134 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_181 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__470__A _470_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__651__RESET_B _425_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__443__B2 _438_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__443__A1 _437_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__576__A2_N _572_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_104 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_48 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__380__A _381_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_203 VGND VPWR sky130_fd_sc_hd__decap_6
X_571_ _679_/Q _571_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_640_ _636_/Y _637_/Y _697_/Q _700_/Q _336_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XPHY_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_170 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_207 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__465__A _472_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_140 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__375__A _375_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__468__A2_N _464_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_173 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_184 VGND VPWR sky130_fd_sc_hd__decap_4
X_554_ _549_/Y _550_/Y _549_/A _550_/A _554_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_485_ _485_/A _485_/Y VGND VPWR sky130_fd_sc_hd__inv_8
Xclkbuf_2_3_0_clk clkbuf_2_3_0_clk/A clkbuf_3_6_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_623_ y _624_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_32_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_122 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__591__B1 _592_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_232 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__582__B1 _681_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_213 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__552__B x[15] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_136 VGND VPWR sky130_fd_sc_hd__fill_2
X_606_ _606_/A _604_/X _606_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_32_213 VGND VPWR sky130_fd_sc_hd__fill_1
X_537_ _544_/A x[13] _537_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_17_243 VGND VPWR sky130_fd_sc_hd__fill_1
X_468_ _463_/Y _464_/Y _466_/X _467_/X _468_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_399_ _398_/A _399_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__462__B _460_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__619__B2 _620_/B VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__555__B1 _553_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_235 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__662__CLK _673_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__563__A _560_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__546__B1 _542_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__676__RESET_B _394_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__473__A _473_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_205 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_15 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__685__CLK _692_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__383__A _381_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_227 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__558__A _558_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__519__B1 _520_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_179 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__378__A _375_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_234 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__700__CLK _698_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_72 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_138 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__443__A2 _438_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__691__RESET_B _376_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_193 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_226 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_215 VGND VPWR sky130_fd_sc_hd__fill_2
X_570_ _570_/A _570_/B _678_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__571__A _679_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_71 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__465__B x[3] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_108 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_clk clk clkbuf_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
X_699_ _342_/X _337_/A _364_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_15_171 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_193 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__481__A _481_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_241 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_38 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_15 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__391__A _373_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_130 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_141 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_230 VGND VPWR sky130_fd_sc_hd__fill_2
X_622_ _622_/A _622_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_553_ _552_/X _553_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_484_ _484_/A _484_/B _654_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XANTENNA__566__A _559_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_145 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_152 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__591__B2 _590_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__476__A _473_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__582__B2 _684_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__582__A1 _578_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_59 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__386__A _386_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_148 VGND VPWR sky130_fd_sc_hd__decap_3
X_605_ _600_/Y _601_/Y _606_/A _604_/X _605_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_17_222 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_233 VGND VPWR sky130_fd_sc_hd__fill_2
X_398_ _398_/A _398_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_536_ _536_/A _536_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_467_ _463_/Y _464_/Y _463_/A _652_/Q _467_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XANTENNA__555__B2 _554_/X VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_2_0_clk clkbuf_2_3_0_clk/A clkbuf_2_2_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__563__B _563_/B VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__546__B2 _543_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__546__A1 _542_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__482__B1 _477_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_195 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_173 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_519_ _513_/Y _514_/Y _520_/A _518_/X _663_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XANTENNA__645__RESET_B _432_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_17 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_93 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__574__A _574_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_250 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__519__B2 _518_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_103 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_42 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__484__A _484_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__652__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_136 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__394__A _394_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_40 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_161 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_70 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_93 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__675__CLK _676_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__479__A _479_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_128 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__660__RESET_B _414_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_249 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__389__A _386_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_109 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_139 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__698__CLK _698_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_94 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_161 VGND VPWR sky130_fd_sc_hd__fill_1
X_698_ _698_/D _630_/A _367_/X _698_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_7_52 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_17 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_164 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_242 VGND VPWR sky130_fd_sc_hd__fill_2
X_621_ _693_/Q _621_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_552_ _559_/A x[15] _552_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_483_ _477_/Y _478_/Y _484_/A _484_/B _483_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XANTENNA__566__B x[17] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_245 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__476__B _474_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__492__A _492_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__582__A2 _579_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__642__D _642_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_105 VGND VPWR sky130_fd_sc_hd__fill_2
X_604_ _600_/Y _601_/Y _600_/A _690_/Q _604_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XANTENNA__577__A _577_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_535_ _669_/Q _535_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_32_215 VGND VPWR sky130_fd_sc_hd__fill_2
X_397_ _373_/A _398_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_466_ _465_/X _466_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_4_171 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__487__A _508_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_97 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_108 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__397__A _373_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__546__A2 _543_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_215 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_95 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__482__A1 _477_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__482__B2 _656_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_518_ _513_/Y _514_/Y _663_/Q _514_/A _518_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_449_ _645_/Q _449_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_9_241 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__685__RESET_B _383_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_39 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__605__A1_N _600_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_222 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_82 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_60 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_159 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_10 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_1_0_clk clkbuf_2_1_0_clk/A clkbuf_3_3_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__484__B _484_/B VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__650__D _650_/D VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__591__A1_N _585_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_104 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_195 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__585__A _683_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__495__A _495_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_184 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_173 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__645__D _645_/D VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__483__A1_N _477_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_151 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_118 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__355__B1 _703_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_51 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_62 VGND VPWR sky130_fd_sc_hd__fill_2
X_697_ _335_/X _697_/Q _368_/X _698_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_30_187 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_154 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__642__CLK _670_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_86 VGND VPWR sky130_fd_sc_hd__fill_2
X_620_ _617_/X _620_/B _692_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_29_210 VGND VPWR sky130_fd_sc_hd__fill_2
X_551_ y _559_/A VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__665__CLK _663_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
X_482_ _477_/Y _478_/Y _477_/A _656_/Q _484_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XANTENNA__576__B1 _577_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_154 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_73 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_83 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_72 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_169 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_224 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_28 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__688__CLK _692_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_202 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_128 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__577__B _575_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_205 VGND VPWR sky130_fd_sc_hd__fill_2
X_603_ _602_/X _606_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_27_72 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_50 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__593__A _685_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_465_ _472_/A x[3] _465_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_534_ _531_/X _532_/X _534_/X VGND VPWR sky130_fd_sc_hd__xor2_4
X_396_ _394_/A _396_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_4_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_76 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_54 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_21 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__487__B x[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_249 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_205 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__653__D _483_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_205 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__703__CLK _698_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_41 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_52 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_93 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__482__A2 _478_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__588__A _616_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_517_ _517_/A _520_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_448_ _643_/Q _446_/X _447_/X _448_/Y VGND VPWR sky130_fd_sc_hd__a21boi_4
X_379_ _373_/A _381_/A VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__634__A2_N _630_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__498__A _495_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__654__RESET_B _421_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__648__D _462_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_234 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_55 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__511__A2_N _507_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__526__A2_N _522_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_226 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_20 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_86 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_138 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__619__A1_N _614_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__661__D _511_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_218 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__355__B2 _352_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__355__A1 _351_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_85 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__596__A _595_/X VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_2_0_0_clk clkbuf_2_1_0_clk/A clkbuf_2_0_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_696_ _696_/D _622_/A _369_/X _692_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_200 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__656__D _491_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_177 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_188 VGND VPWR sky130_fd_sc_hd__fill_1
X_550_ _550_/A _550_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_481_ _481_/A _484_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_16_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_126 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__342__A2_N _338_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__576__B2 _575_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_144 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_85 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_236 VGND VPWR sky130_fd_sc_hd__fill_2
X_679_ _679_/D _679_/Q _390_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__679__RESET_B _390_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__497__A1_N _492_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_118 VGND VPWR sky130_fd_sc_hd__decap_4
X_602_ _616_/A x[22] _602_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_27_62 VGND VPWR sky130_fd_sc_hd__fill_2
X_533_ _528_/Y _529_/Y _531_/X _532_/X _667_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_464_ _652_/Q _464_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_40_250 VGND VPWR sky130_fd_sc_hd__decap_3
X_395_ _394_/A _395_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__701__RESET_B _362_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_195 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_44 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_239 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__655__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_228 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_143 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__588__B x[20] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__467__B1 _463_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_61 VGND VPWR sky130_fd_sc_hd__fill_1
X_378_ _375_/A _378_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_516_ _544_/A x[10] _517_/A VGND VPWR sky130_fd_sc_hd__and2_4
X_447_ _643_/Q _446_/X _447_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_20_209 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__678__CLK _676_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__498__B _496_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_19 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__664__D _664_/D VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__694__RESET_B _371_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_52 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__599__A _596_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__612__B1 _610_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_78 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__659__D _504_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_183 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_153 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_62 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_197 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_172 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__355__A2 _352_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_75 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_101 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_153 VGND VPWR sky130_fd_sc_hd__fill_2
X_695_ _634_/X _629_/A _370_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_30_145 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_44 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_212 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__672__D _548_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_123 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_134 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_156 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_234 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_64 VGND VPWR sky130_fd_sc_hd__fill_2
X_480_ _508_/A x[5] _481_/A VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_32_41 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_30 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__400__A _398_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_678_ _678_/D _558_/A _392_/X _676_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__648__RESET_B _429_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_229 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_237 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_215 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__667__D _667_/D VGND VPWR sky130_fd_sc_hd__diode_2
X_601_ _690_/Q _601_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_17_226 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_237 VGND VPWR sky130_fd_sc_hd__decap_6
X_394_ _394_/A _394_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_532_ _528_/Y _529_/Y _528_/A _670_/Q _532_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_463_ _463_/A _463_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_4_163 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_240 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__356__A2_N _352_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_87 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__467__A1 _463_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_199 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_177 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_111 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__467__B2 _652_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_515_ _479_/A _544_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_377_ _375_/A _377_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_211 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_233 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_240 VGND VPWR sky130_fd_sc_hd__decap_4
X_446_ _479_/A x[31] _446_/X VGND VPWR sky130_fd_sc_hd__and2_4
XANTENNA__680__D _680_/D VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__663__RESET_B _411_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_64 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_30 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__599__B _597_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__612__B2 _611_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__645__CLK _663_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
X_429_ _428_/X _429_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_36_162 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__675__D _562_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_52 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_184 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_151 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__668__CLK _670_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_187 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__403__A _372_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_165 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_143 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__597__B1 _685_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__349__B1 _350_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_154 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_10 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_43 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_98 VGND VPWR sky130_fd_sc_hd__decap_4
X_694_ _628_/X _615_/A _371_/X _676_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_30_124 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_176 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_198 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__503__B1 _499_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_224 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_146 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_124 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_135 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_32 VGND VPWR sky130_fd_sc_hd__fill_2
X_677_ _677_/D _677_/Q _393_/X _676_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__688__RESET_B _380_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__683__D _591_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__501__A _508_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_600_ _600_/A _600_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_27_86 VGND VPWR sky130_fd_sc_hd__fill_2
X_531_ _530_/X _531_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_32_219 VGND VPWR sky130_fd_sc_hd__decap_3
X_393_ _394_/A _393_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_462_ _459_/X _460_/X _462_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_4_131 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_13 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__411__A _414_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__678__D _678_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_252 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__467__A2 _464_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_123 VGND VPWR sky130_fd_sc_hd__decap_4
X_514_ _514_/A _514_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_376_ _375_/A _376_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_445_ _445_/A _445_/B _642_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_9_245 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__406__A _409_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_160 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_21 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_204 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_215 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_97 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_108 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_25 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_36 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_47 VGND VPWR sky130_fd_sc_hd__fill_2
X_428_ _422_/A _428_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_359_ rst _372_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_36_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_130 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_108 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__691__D _619_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_45 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_177 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_31 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_174 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_163 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_199 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_7 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_111 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_100 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__597__B2 _688_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__597__A1 _593_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_130 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__349__B2 _348_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__686__D _599_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_144 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_55 VGND VPWR sky130_fd_sc_hd__fill_2
X_693_ _693_/D _693_/Q _374_/X _676_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_15_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_136 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_111 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__503__B2 _500_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__503__A1 _499_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__414__A _414_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__658__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_169 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_22 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__497__B1 _495_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_129 VGND VPWR sky130_fd_sc_hd__fill_2
X_676_ _676_/D _550_/A _394_/X _676_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_35_228 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__409__A _409_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_173 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_195 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_209 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_250 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__657__RESET_B _418_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__501__B x[8] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_209 VGND VPWR sky130_fd_sc_hd__decap_4
X_530_ _544_/A x[12] _530_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_461_ _456_/Y _457_/Y _459_/X _460_/X _647_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_40_242 VGND VPWR sky130_fd_sc_hd__decap_8
X_392_ _394_/A _392_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_58 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_25 VGND VPWR sky130_fd_sc_hd__decap_6
X_659_ _504_/X _499_/A _415_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_23_209 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__602__A _616_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__694__D _628_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_209 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__633__B1 _629_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_56 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__512__A _509_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_5_0_clk_A clkbuf_2_2_0_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_64 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_20 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_135 VGND VPWR sky130_fd_sc_hd__fill_2
X_444_ _437_/Y _438_/Y _445_/A _445_/B _444_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_513_ _663_/Q _513_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_375_ _375_/A _375_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_202 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__422__A _422_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__689__D _612_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__672__RESET_B _399_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_32 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__507__A _507_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_238 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_234 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_59 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__417__A _420_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_427_ _423_/A _427_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_358_ _366_/A _358_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__691__CLK _692_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_24 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_57 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_44 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_156 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_98 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_2_2_0_clk_A clkbuf_2_3_0_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_252 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_134 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_123 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__597__A2 _594_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_142 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__540__A1_N _535_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__555__A1_N _549_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__610__A _610_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_123 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_67 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__520__A _520_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_692_ _692_/D _692_/Q _375_/X _692_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_159 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_14 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_189 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__503__A2 _500_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__704__RESET_B _358_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_204 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__430__A _428_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_104 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__340__A _339_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__697__D _335_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_29_226 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_204 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_44 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_22 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_11 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__515__A _479_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_148 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__497__B2 _496_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_181 VGND VPWR sky130_fd_sc_hd__decap_4
X_675_ _562_/X _675_/Q _395_/X _676_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__425__A _423_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_141 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_192 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__697__RESET_B _368_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_90 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_clkbuf_3_1_0_clk_A clkbuf_2_0_0_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
X_391_ _373_/A _394_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_27_55 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_33 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_240 VGND VPWR sky130_fd_sc_hd__decap_4
X_460_ _456_/Y _457_/Y _456_/A _650_/Q _460_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_4_199 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__648__CLK _663_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_232 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_221 VGND VPWR sky130_fd_sc_hd__fill_2
X_658_ _498_/X _486_/A _417_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_589_ _589_/A _592_/A VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__602__B x[22] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__633__B2 _630_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__633__A1 _629_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__512__B _512_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_32 VGND VPWR sky130_fd_sc_hd__fill_2
X_512_ _509_/X _512_/B _512_/X VGND VPWR sky130_fd_sc_hd__xor2_4
X_374_ _375_/A _374_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_443_ _437_/Y _438_/Y _437_/A _438_/A _445_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_13_221 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_191 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__613__A _610_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_12 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__641__RESET_B _436_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_89 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__523__A _544_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__decap_4
X_357_ _354_/X _355_/X _357_/X VGND VPWR sky130_fd_sc_hd__xor2_4
X_426_ _423_/A _426_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__433__A _428_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__533__B1 _531_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__608__A _692_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_187 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_154 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_143 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__343__A _340_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_36 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_132 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_56 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_89 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__428__A _422_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_121 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_176 VGND VPWR sky130_fd_sc_hd__decap_3
X_409_ _409_/A _409_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__338__A _338_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__520__B _518_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_691_ _619_/X _691_/Q _376_/X _692_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__681__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_157 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_48 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_7 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__461__A2_N _457_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__621__A _693_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__531__A _530_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_674_ _556_/X _543_/A _396_/X _673_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__569__A1_N _564_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__441__A _472_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_219 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__616__A _616_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__351__A _703_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__666__RESET_B _407_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_233 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_67 VGND VPWR sky130_fd_sc_hd__fill_2
X_390_ _386_/A _390_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_4_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_101 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_134 VGND VPWR sky130_fd_sc_hd__fill_2
X_657_ _497_/X _492_/A _418_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__436__A _366_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_588_ _616_/A x[20] _589_/A VGND VPWR sky130_fd_sc_hd__and2_4
XANTENNA__633__A2 _630_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_200 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__346__A _624_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_244 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_47 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_115 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_7 VGND VPWR sky130_fd_sc_hd__fill_2
X_511_ _506_/Y _507_/Y _509_/X _512_/B _511_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_373_ _373_/A _375_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_442_ _442_/A _445_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_237 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_211 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__613__B _611_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_68 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_78 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_56 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_12 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__681__RESET_B _388_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__523__B x[11] VGND VPWR sky130_fd_sc_hd__diode_2
X_425_ _423_/A _425_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_356_ _351_/Y _352_/Y _354_/X _355_/X _356_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XANTENNA__533__B2 _532_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__624__A _624_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__343__B _343_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_103 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_34 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_177 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_155 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__460__B1 _456_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__534__A _531_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_9 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_169 VGND VPWR sky130_fd_sc_hd__fill_2
X_408_ _409_/A _408_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_339_ _624_/A x[28] _339_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_2_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_60 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_180 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__354__A _353_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_690_ _613_/X _690_/Q _377_/X _692_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__529__A _670_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_128 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_106 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_80 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_228 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__439__A y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_68 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__583__A2_N _579_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__598__A2_N _594_/Y VGND VPWR sky130_fd_sc_hd__diode_2
X_673_ _555_/X _549_/A _398_/X _673_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_11_150 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__441__B x[0] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_176 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_242 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__616__B x[24] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__632__A _632_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__671__CLK _676_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_212 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__542__A _542_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_113 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__627__B1 _628_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_17 VGND VPWR sky130_fd_sc_hd__fill_2
X_656_ _491_/X _656_/Q _419_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__475__A2_N _471_/Y VGND VPWR sky130_fd_sc_hd__diode_2
X_587_ y _616_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_16_220 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_90 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_245 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__694__CLK _676_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__452__A _451_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__618__B1 _691_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_212 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__346__B x[29] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__362__A _363_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_127 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_149 VGND VPWR sky130_fd_sc_hd__fill_2
X_510_ _506_/Y _507_/Y _661_/Q _507_/A _512_/B VGND VPWR sky130_fd_sc_hd__o22a_4
X_441_ _472_/A x[0] _442_/A VGND VPWR sky130_fd_sc_hd__and2_4
XANTENNA__537__A _544_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_372_ _372_/A _373_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_13_245 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__447__A _643_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_639_ _638_/X _639_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_71 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_175 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_164 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__357__A _354_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_25 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_204 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_215 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_24 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_219 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__650__RESET_B _426_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_424_ _423_/A _424_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_355_ _351_/Y _352_/Y _703_/Q _352_/A _355_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_30_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_167 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__624__B x[25] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_16 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_123 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__460__B2 _650_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__460__A1 _456_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__534__B _532_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__550__A _550_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__700__D _700_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_134 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_104 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_115 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_338_ _338_/A _338_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_407_ _409_/A _407_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_21_26 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__635__A _635_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__370__A _369_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_59 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__545__A _544_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_192 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_148 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_7 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__455__A _452_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_192 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_240 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__365__A _372_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_129 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_26 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_140 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_240 VGND VPWR sky130_fd_sc_hd__decap_12
X_672_ _548_/X _536_/A _399_/X _673_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_11_173 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__590__B1 _683_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_80 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_144 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__342__B1 _340_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_195 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_240 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_93 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__675__RESET_B _395_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_221 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_210 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__627__B2 _628_/B VGND VPWR sky130_fd_sc_hd__diode_2
X_655_ _655_/D _485_/A _420_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_31_213 VGND VPWR sky130_fd_sc_hd__fill_2
X_586_ _686_/Q _586_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__618__B2 _615_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__618__A1 _614_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__554__B1 _549_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_16 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_68 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_13 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_139 VGND VPWR sky130_fd_sc_hd__fill_2
X_371_ _369_/A _371_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__537__B x[13] VGND VPWR sky130_fd_sc_hd__diode_2
X_440_ _479_/A _472_/A VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__553__A _552_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_206 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_217 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__703__D _356_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_183 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__661__CLK _673_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
X_638_ _624_/A x[27] _638_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_569_ _564_/Y _565_/Y _570_/A _570_/B _677_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XANTENNA__447__B _446_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__463__A _463_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_250 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_94 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_154 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__357__B _355_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__638__A _624_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__373__A _373_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_59 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_37 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_238 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__690__RESET_B _377_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__548__A _545_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_19 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__684__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
X_423_ _423_/A _423_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_354_ _353_/X _354_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_242 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__518__B1 _663_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_80 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_135 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__458__A _472_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_28 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__368__A _369_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_15 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_48 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_116 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_168 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__460__A2 _457_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_234 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_146 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_171 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_80 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_149 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_138 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_337_ _337_/A _337_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_406_ _409_/A _406_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_37_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_84 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_1_0_clk clkbuf_0_clk/X clkbuf_2_3_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_24_138 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__635__B _635_/B VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__444__A1_N _437_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_116 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_171 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_208 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__455__B _453_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__471__A _471_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_171 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_219 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_16 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_37 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_26 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__381__A _381_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_152 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__556__A _553_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_252 VGND VPWR sky130_fd_sc_hd__fill_1
X_671_ _547_/X _542_/A _400_/X _676_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_7_123 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__590__B2 _686_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__590__A1 _585_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__342__B2 _343_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_34_233 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__466__A _465_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_83 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__376__A _375_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_37 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__644__RESET_B _433_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_159 VGND VPWR sky130_fd_sc_hd__fill_2
X_654_ _654_/D _471_/A _421_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XPHY_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_236 VGND VPWR sky130_fd_sc_hd__fill_2
X_585_ _683_/Q _585_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__618__A2 _615_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_170 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__554__B2 _550_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__554__A1 _549_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_107 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__490__B1 _488_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_225 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_236 VGND VPWR sky130_fd_sc_hd__fill_2
X_370_ _369_/A _370_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_637_ _700_/Q _637_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_499_ _499_/A _499_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_568_ _564_/Y _565_/Y _677_/Q _565_/A _570_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_5_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__638__B x[27] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__548__B _546_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_422_ _422_/A _423_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_353_ _479_/A x[30] _353_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_14_60 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__518__A1 _513_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__518__B2 _514_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__564__A _677_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__454__B1 _452_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__458__B x[2] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_136 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_114 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__384__A _381_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_202 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__559__A _559_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__612__A1_N _607_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__651__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_246 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__627__A1_N _621_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_125 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_405_ _409_/A _405_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_336_ _639_/X _336_/B _698_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_2_52 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__469__A _466_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_172 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__674__CLK _673_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__379__A _373_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__669__RESET_B _402_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_19 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_72 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_91 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__504__A1_N _499_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_183 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__697__CLK _698_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__519__A1_N _513_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_220 VGND VPWR sky130_fd_sc_hd__fill_2
X_670_ _541_/X _670_/Q _401_/X _670_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__556__B _554_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_93 VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0_0_clk clkbuf_0_clk/X clkbuf_2_1_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_22_60 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_113 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__572__A _572_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_120 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__590__A2 _586_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__490__A1_N _485_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_220 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_40 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_237 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__392__A _394_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__684__RESET_B _384_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_138 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_127 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__567__A _566_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_653_ _483_/X _477_/A _423_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_16_212 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_584_ _581_/X _582_/X _584_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_16_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_82 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_193 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_3 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__477__A _477_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_215 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__554__A2 _550_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__490__B2 _489_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__387__A _386_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__335__A1_N _636_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_215 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_81 VGND VPWR sky130_fd_sc_hd__fill_2
X_567_ _566_/X _570_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_636_ _697_/Q _636_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_498_ _495_/X _496_/X _498_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_39_123 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_17 VGND VPWR sky130_fd_sc_hd__fill_2
X_421_ _420_/A _421_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_352_ _352_/A _352_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__518__A2 _514_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_60 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__580__A _559_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_91 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_8 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__454__B2 _453_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_619_ _614_/Y _615_/Y _617_/X _620_/B _619_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_36_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_159 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_192 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__559__B x[16] VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_82 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_170 VGND VPWR sky130_fd_sc_hd__fill_2
X_404_ _422_/A _409_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_41_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_92 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_335_ _636_/Y _637_/Y _639_/X _336_/B _335_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XANTENNA__485__A _485_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_97 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__469__B _467_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_195 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_162 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__395__A _394_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_195 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_184 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__533__A2_N _529_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_84 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_140 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_17 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__641__CLK _670_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_187 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__575__B1 _679_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_72 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_169 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_165 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_7 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__664__CLK _663_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__653__RESET_B _423_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__687__CLK _692_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
X_652_ _476_/X _652_/Q _424_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_583_ _578_/Y _579_/Y _581_/X _582_/X _681_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XPHY_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_82 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__493__A _660_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__539__B1 _669_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__643__D _447_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_16 VGND VPWR sky130_fd_sc_hd__fill_2
X_704_ _357_/X _704_/Q _358_/X _698_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__578__A _681_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_175 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_153 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_93 VGND VPWR sky130_fd_sc_hd__fill_2
X_566_ _559_/A x[17] _566_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_635_ _635_/A _635_/B _696_/D VGND VPWR sky130_fd_sc_hd__xor2_4
X_497_ _492_/Y _493_/Y _495_/X _496_/X _497_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XANTENNA__702__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_220 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_231 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_242 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_75 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_31 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__488__A _487_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_208 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__398__A _398_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_420_ _420_/A _420_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_351_ _703_/Q _351_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__580__B x[19] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_73 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_234 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_549_ _549_/A _549_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_618_ _614_/Y _615_/Y _691_/Q _615_/A _620_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XANTENNA__349__A1_N _344_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_171 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_39 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_215 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_138 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_83 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_152 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_72 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_108 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_61 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_83 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_50 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_403_ _372_/A _422_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_2_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_141 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_193 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__651__D _475_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__678__RESET_B _392_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_3 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__586__A _686_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_196 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__646__D _455_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__700__RESET_B _363_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_144 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__575__A1 _571_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__575__B2 _572_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_111 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_133 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_51 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_137 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_188 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_199 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_170 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_206 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_236 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_225 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__547__A2_N _543_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__693__RESET_B _374_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_217 VGND VPWR sky130_fd_sc_hd__fill_2
X_651_ _475_/X _470_/A _425_/X _659_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_582_ _578_/Y _579_/Y _681_/Q _684_/Q _582_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_16_203 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_95 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_184 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__539__B2 _536_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__539__A1 _535_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_28 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__475__B1 _473_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__654__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_187 VGND VPWR sky130_fd_sc_hd__fill_2
X_703_ _356_/X _703_/Q _363_/A _698_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_634_ _629_/Y _630_/Y _635_/A _635_/B _634_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_496_ _492_/Y _493_/Y _492_/A _660_/Q _496_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XANTENNA__594__A _688_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_565_ _565_/A _565_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_8_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_103 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__654__D _654_/D VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__677__CLK _676_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
X_350_ _350_/A _348_/X _702_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_14_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_84 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__589__A _589_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_617_ _616_/X _617_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__611__B1 _607_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_139 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_106 VGND VPWR sky130_fd_sc_hd__fill_1
X_548_ _545_/X _546_/X _548_/X VGND VPWR sky130_fd_sc_hd__xor2_4
X_479_ _479_/A _508_/A VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__499__A _499_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__649__D _468_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_117 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_84 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_175 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_120 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_73 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_62 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
X_402_ _398_/A _402_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_41_83 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_44 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_175 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_31 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_42 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_53 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__647__RESET_B _430_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_112 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__662__D _512_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_41 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_30 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__575__A2 _572_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_156 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_54 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_87 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_182 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__657__D _497_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_119 VGND VPWR sky130_fd_sc_hd__fill_1
X_650_ _650_/D _650_/Q _426_/X _663_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XPHY_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__662__RESET_B _412_/X VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_581_ _580_/X _581_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_16_215 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_41 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_52 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_174 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_163 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_240 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__539__A2 _536_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__475__B2 _474_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_111 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_144 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_62 VGND VPWR sky130_fd_sc_hd__fill_2
X_702_ _702_/D _338_/A _361_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_633_ _629_/Y _630_/Y _629_/A _630_/A _635_/B VGND VPWR sky130_fd_sc_hd__o22a_4
X_495_ _495_/A _495_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_564_ _677_/Q _564_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_5_99 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__670__D _541_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__448__A1 _643_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_4_0_clk_A clkbuf_2_2_0_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_41 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_203 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__611__A1 _607_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__611__B2 _692_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_616_ _616_/A x[24] _616_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_547_ _542_/Y _543_/Y _545_/X _546_/X _547_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_29_170 VGND VPWR sky130_fd_sc_hd__fill_2
X_478_ _656_/Q _478_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_35_184 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_162 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__665__D _526_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__644__CLK _698_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_162 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
X_401_ _398_/A _401_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_85 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_143 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_74 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_51 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_8 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_56 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__667__CLK _670_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_184 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__348__B1 _701_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_154 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__511__B1 _509_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__687__RESET_B _381_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_51 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_clkbuf_2_1_0_clk_A clkbuf_2_1_0_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_187 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_224 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__569__B1 _570_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_224 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_20 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_106 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_44 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_249 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__673__D _555_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_109 VGND VPWR sky130_fd_sc_hd__fill_2
X_580_ _559_/A x[19] _580_/X VGND VPWR sky130_fd_sc_hd__and2_4
XPHY_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_86 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_131 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__401__A _398_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_252 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_219 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_208 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__668__D _534_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_0_0_clk_A clkbuf_2_0_0_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_123 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_156 VGND VPWR sky130_fd_sc_hd__decap_3
X_563_ _560_/X _563_/B _676_/D VGND VPWR sky130_fd_sc_hd__xor2_4
X_701_ _701_/D _701_/Q _362_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_632_ _632_/A _635_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_494_ _508_/A x[7] _495_/A VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_8_201 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__448__A2 _446_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_171 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_65 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_97 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_64 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_51 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__611__A2 _608_/Y VGND VPWR sky130_fd_sc_hd__diode_2
X_615_ _615_/A _615_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_546_ _542_/Y _543_/Y _542_/A _543_/A _546_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_29_193 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_182 VGND VPWR sky130_fd_sc_hd__fill_1
X_477_ _477_/A _477_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_35_196 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_141 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__681__D _681_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_9 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_111 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VPWR sky130_fd_sc_hd__decap_3
X_400_ _398_/A _400_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_185 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_42 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_96 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_199 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_188 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__348__B2 _704_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__348__A1 _344_/Y VGND VPWR sky130_fd_sc_hd__diode_2
X_529_ _670_/Q _529_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_17_141 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__676__D _676_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_199 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_188 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_133 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__511__B2 _512_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_66 VGND VPWR sky130_fd_sc_hd__decap_6
XANTENNA__656__RESET_B _419_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_111 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__404__A _422_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_236 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__569__B2 _570_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_136 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__562__A1_N _557_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__657__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_98 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_76 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_169 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__496__B1 _492_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_206 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_236 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_162 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_191 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_217 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_206 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_53 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_209 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__671__RESET_B _400_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_121 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__454__A1_N _449_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_198 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_231 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__684__D _592_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__502__A _502_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_179 VGND VPWR sky130_fd_sc_hd__fill_2
X_700_ _700_/D _700_/Q _363_/X _698_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_493_ _660_/Q _493_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_562_ _557_/Y _558_/Y _560_/X _563_/B _562_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_28_86 VGND VPWR sky130_fd_sc_hd__fill_2
X_631_ _624_/A x[26] _632_/A VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_8_235 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_220 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__412__A _414_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_5_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_46 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__679__D _679_/D VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__605__B1 _606_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_99 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_76 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_216 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_238 VGND VPWR sky130_fd_sc_hd__fill_2
X_614_ _691_/Q _614_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_545_ _544_/X _545_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_476_ _473_/X _474_/X _476_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XANTENNA__407__A _409_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_175 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__703__RESET_B _363_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__690__CLK _692_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_156 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_123 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_76 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_175 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_54 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_54 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_167 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_31 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_36 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__348__A2 _345_/Y VGND VPWR sky130_fd_sc_hd__diode_2
X_459_ _458_/X _459_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_528_ _528_/A _528_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_17_175 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_197 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__600__A _600_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__692__D _692_/D VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__605__A2_N _601_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_89 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_64 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__696__RESET_B _369_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_75 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_145 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__448__B1_N _447_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__420__A _420_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_160 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__591__A2_N _586_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_104 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_148 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__687__D _605_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_204 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_115 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__505__A _502_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__496__B2 _660_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__496__A1 _492_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_204 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__415__A _414_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_240 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__483__A2_N _478_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_16_207 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_33 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_44 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_55 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_32 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_155 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_111 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_100 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__576__A1_N _571_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__647__CLK _663_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125 VGND VPWR sky130_fd_sc_hd__fill_2
X_630_ _630_/A _630_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_492_ _492_/A _492_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_561_ _557_/Y _558_/Y _675_/Q _558_/A _563_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_39_129 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__603__A _602_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__605__B2 _604_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__695__D _634_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_56 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_89 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__468__A1_N _463_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_42 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__513__A _663_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_613_ _610_/X _611_/X _613_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_29_184 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_162 VGND VPWR sky130_fd_sc_hd__fill_2
X_475_ _470_/Y _471_/Y _473_/X _474_/X _475_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_544_ _544_/A x[14] _544_/X VGND VPWR sky130_fd_sc_hd__and2_4
XANTENNA__423__A _423_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__532__B1 _528_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_132 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_90 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__508__A _508_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_77 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_66 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_113 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__418__A _420_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_527_ _524_/X _525_/X _666_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_17_132 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_190 VGND VPWR sky130_fd_sc_hd__fill_2
X_458_ _472_/A x[2] _458_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_389_ _386_/A _389_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_23_113 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_43 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_98 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__665__RESET_B _408_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_249 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__680__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_12 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__505__B _503_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__496__A2 _493_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_67 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_56 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__521__A _665_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_216 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_36 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_58 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__431__A _428_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__619__A2_N _615_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__606__A _606_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__698__D _698_/D VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_78 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__516__A _544_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_189 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_167 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_123 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__680__RESET_B _389_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_241 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__426__A _423_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_92 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__336__A _639_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_560_ _559_/X _560_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_28_66 VGND VPWR sky130_fd_sc_hd__decap_12
X_491_ _488_/X _489_/X _491_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_8_215 VGND VPWR sky130_fd_sc_hd__decap_3
X_689_ _612_/X _607_/A _378_/X _692_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_38_163 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_130 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__497__A2_N _493_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_45 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_23 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_79 VGND VPWR sky130_fd_sc_hd__fill_2
X_612_ _607_/Y _608_/Y _610_/X _611_/X _612_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_39_87 VGND VPWR sky130_fd_sc_hd__fill_2
X_543_ _543_/A _543_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_29_174 VGND VPWR sky130_fd_sc_hd__decap_8
X_474_ _470_/Y _471_/Y _470_/A _471_/A _474_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XANTENNA__532__A1 _528_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__532__B2 _670_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_199 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_188 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_166 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__614__A _691_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_111 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__508__B x[9] VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_78 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_89 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_45 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_55 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__524__A _524_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_147 VGND VPWR sky130_fd_sc_hd__fill_2
X_526_ _521_/Y _522_/Y _524_/X _525_/X _526_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_17_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_158 VGND VPWR sky130_fd_sc_hd__decap_4
X_388_ _386_/A _388_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__434__A _366_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_457_ _650_/Q _457_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__609__A _616_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_158 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__344__A _701_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_158 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_228 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__429__A _428_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_509_ _508_/X _509_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_173 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_250 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_228 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__339__A _624_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_24 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_139 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_176 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_198 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_250 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_231 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__606__B _604_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__622__A _622_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_220 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_78 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__516__B x[10] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__670__CLK _670_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__626__B1 _693_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_212 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__442__A _442_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__617__A _616_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_212 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__693__CLK _676_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_223 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__352__A _352_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__336__B _336_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_149 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_78 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_23 VGND VPWR sky130_fd_sc_hd__fill_2
X_490_ _485_/Y _486_/Y _488_/X _489_/X _655_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XANTENNA__527__A _524_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_8_205 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_8 VGND VPWR sky130_fd_sc_hd__fill_2
X_688_ _606_/X _688_/Q _380_/X _692_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__437__A _437_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__347__A _347_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_47 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_69 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_99 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_55 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__659__RESET_B _415_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_611_ _607_/Y _608_/Y _607_/A _692_/Q _611_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_542_ _542_/A _542_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_473_ _473_/A _473_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__532__A2 _529_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_145 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_123 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_7_0_clk clkbuf_3_6_0_clk/A _692_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_6_70 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__630__A _630_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_189 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_145 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_13 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_34 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_79 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_78 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VPWR sky130_fd_sc_hd__decap_3
X_525_ _521_/Y _522_/Y _665_/Q _668_/Q _525_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_456_ _456_/A _456_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_17_123 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_145 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_189 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_181 VGND VPWR sky130_fd_sc_hd__decap_3
X_387_ _386_/A _387_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__450__A _648_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__609__B x[23] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__625__A _625_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_137 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__360__A _372_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_36_23 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_115 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__535__A _669_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__674__RESET_B _396_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_508_ _508_/A x[9] _508_/X VGND VPWR sky130_fd_sc_hd__and2_4
XANTENNA__445__A _445_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_439_ y _479_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_13_181 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__339__B x[28] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_11_129 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_240 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__341__B1 _337_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_144 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_140 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_35 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__626__A1 _621_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__626__B2 _622_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__562__B1 _560_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_202 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_235 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_202 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__543__A _543_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__527__B _525_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_202 VGND VPWR sky130_fd_sc_hd__fill_1
X_687_ _605_/X _600_/A _381_/X _692_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_18_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_154 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__628__A _628_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__660__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__526__B1 _524_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__363__A _363_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_610_ _610_/A _610_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_39_34 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_12 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_132 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_121 VGND VPWR sky130_fd_sc_hd__fill_1
X_472_ _472_/A x[4] _473_/A VGND VPWR sky130_fd_sc_hd__and2_4
XANTENNA__699__RESET_B _364_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__538__A _537_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_541_ _541_/A _539_/X _541_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_4_220 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_113 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_102 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__683__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_35_179 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_82 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_116 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_69 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__358__A _366_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_212 VGND VPWR sky130_fd_sc_hd__decap_4
X_524_ _524_/A _524_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_455_ _452_/X _453_/X _455_/X VGND VPWR sky130_fd_sc_hd__xor2_4
X_386_ _386_/A _386_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_15_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_27 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_49 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_68 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__551__A y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__701__D _701_/D VGND VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_3_6_0_clk clkbuf_3_6_0_clk/A _676_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__643__RESET_B _434_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_507_ _507_/A _507_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_26_90 VGND VPWR sky130_fd_sc_hd__fill_2
X_369_ _369_/A _369_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_438_ _438_/A _438_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__445__B _445_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_153 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_164 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_108 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__634__A1_N _629_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_83 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__636__A _697_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__371__A _369_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_211 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_208 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_222 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_152 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__341__B2 _338_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__341__A1 _337_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_10_163 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__456__A _456_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__511__A1_N _506_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_17_37 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_48 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__526__A1_N _521_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__366__A _366_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_159 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_115 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_104 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__626__A2 _622_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_233 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__562__B2 _563_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_91 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_71 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_36 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_90 VGND VPWR sky130_fd_sc_hd__fill_2
X_686_ _599_/X _686_/Q _382_/X _692_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_7_240 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_133 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__628__B _628_/B VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__526__B2 _525_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_37 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_46 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_166 VGND VPWR sky130_fd_sc_hd__fill_2
X_540_ _535_/Y _536_/Y _541_/A _539_/X _669_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_471_ _471_/A _471_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__668__RESET_B _405_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__704__D _357_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__342__A1_N _337_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__453__B1 _645_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_669_ _669_/D _669_/Q _402_/X _698_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__464__A _652_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__444__B1 _445_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__639__A _638_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_139 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_191 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__374__A _375_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_59 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_47 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__549__A _549_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_523_ _544_/A x[11] _524_/A VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_17_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_194 VGND VPWR sky130_fd_sc_hd__decap_3
X_454_ _449_/Y _450_/Y _452_/X _453_/X _645_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_385_ _373_/A _386_/A VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__459__A _458_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__650__CLK _663_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_128 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_117 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_172 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_47 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__369__A _369_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__673__CLK _673_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
X_506_ _661_/Q _506_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__683__RESET_B _386_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_437_ _437_/A _437_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_9_132 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_150 VGND VPWR sky130_fd_sc_hd__fill_2
X_368_ _369_/A _368_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_16 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__696__CLK _692_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_113 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__341__A2 _338_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_7 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_223 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__540__A2_N _536_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__555__A2_N _550_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__472__A _472_/A VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_201 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA__382__A _381_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_127 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_5_0_clk clkbuf_2_2_0_clk/X _695_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__557__A _675_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_30_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_215 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__377__A _375_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_215 VGND VPWR sky130_fd_sc_hd__decap_3
X_685_ _598_/X _685_/Q _383_/X _692_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_18_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_189 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_123 VGND VPWR sky130_fd_sc_hd__fill_2
X_470_ _470_/A _470_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__570__A _570_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__453__A1 _449_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_137 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_91 VGND VPWR sky130_fd_sc_hd__fill_2
X_599_ _596_/X _597_/X _599_/X VGND VPWR sky130_fd_sc_hd__xor2_4
XANTENNA__453__B2 _648_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_668_ _534_/X _668_/Q _405_/X _670_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_6_40 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__480__A _508_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_115 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_104 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__444__B2 _445_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_41_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_38 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_15 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__390__A _386_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_1_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_225 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_129 VGND VPWR sky130_fd_sc_hd__decap_12
X_522_ _668_/Q _522_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_453_ _449_/Y _450_/Y _645_/Q _648_/Q _453_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_17_104 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__565__A _565_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_181 VGND VPWR sky130_fd_sc_hd__fill_2
X_384_ _381_/A _384_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_16_170 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_192 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_184 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__385__A _373_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA_clkbuf_3_7_0_clk_A clkbuf_3_6_0_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_173 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__356__A1_N _351_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_3 VGND VPWR sky130_fd_sc_hd__fill_2
X_505_ _502_/X _503_/X _505_/X VGND VPWR sky130_fd_sc_hd__xor2_4
X_436_ _366_/A _436_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__652__RESET_B _424_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_177 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_184 VGND VPWR sky130_fd_sc_hd__decap_4
X_367_ _369_/A _367_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__583__B1 _581_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__335__B1 _639_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_187 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_50 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_9 VGND VPWR sky130_fd_sc_hd__fill_2
X_419_ _420_/A _419_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__472__B x[4] VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_213 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__663__CLK _663_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__547__B1 _545_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__573__A _559_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_7 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__686__CLK _692_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_86 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_227 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_27 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__393__A _394_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_684_ _592_/X _684_/Q _384_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_18_93 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__569__A2_N _565_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_102 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__478__A _656_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_4_0_clk clkbuf_2_2_0_clk/X _698_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XANTENNA__701__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_102 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_190 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_113 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__388__A _386_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__570__B _570_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_4_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_212 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__677__RESET_B _393_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__453__A2 _450_/Y VGND VPWR sky130_fd_sc_hd__diode_2
X_598_ _593_/Y _594_/Y _596_/X _597_/X _598_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_667_ _667_/D _528_/A _406_/X _670_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA_clkbuf_1_1_0_clk_A clkbuf_0_clk/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__480__B x[5] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_149 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_3_3_0_clk_A clkbuf_3_3_0_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_25_193 VGND VPWR sky130_fd_sc_hd__fill_2
X_383_ _381_/A _383_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_521_ _665_/Q _521_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_452_ _451_/X _452_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_15_50 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__581__A _580_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__491__A _488_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__641__D _444_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_241 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_119 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_152 VGND VPWR sky130_fd_sc_hd__fill_1
X_504_ _499_/Y _500_/Y _502_/X _503_/X _504_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_26_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_71 VGND VPWR sky130_fd_sc_hd__fill_2
X_435_ _366_/A _435_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_123 VGND VPWR sky130_fd_sc_hd__fill_2
X_366_ _366_/A _369_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_42_92 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__692__RESET_B _375_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_53 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_200 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__486__A _486_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__583__B2 _582_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__335__B2 _336_/B VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__396__A _394_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_42_236 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_104 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_144 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_40 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA_clkbuf_2_0_0_clk_A clkbuf_2_1_0_clk/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_33_236 VGND VPWR sky130_fd_sc_hd__fill_2
X_418_ _420_/A _418_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_349_ _344_/Y _345_/Y _350_/A _348_/X _701_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_5_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_28 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_206 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__547__B2 _546_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__573__B x[18] VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__483__B1 _484_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_2_173 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_206 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_52 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_85 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__474__B1 _470_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_206 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__584__A _581_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_683_ _591_/X _683_/Q _386_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_34_93 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__653__CLK _659_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__494__A _508_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__644__D _448_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_38 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_16 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__676__CLK _676_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__579__A _684_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_73 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_84 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_128 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_106 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__646__RESET_B _431_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_28_180 VGND VPWR sky130_fd_sc_hd__decap_4
X_597_ _593_/Y _594_/Y _685_/Q _688_/Q _597_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_666_ _666_/D _514_/A _407_/X _670_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_6_86 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__699__CLK _695_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__399__A _398_/A VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_8 VGND VPWR sky130_fd_sc_hd__fill_2
X_520_ _520_/A _518_/X _664_/D VGND VPWR sky130_fd_sc_hd__xor2_4
XFILLER_32_109 VGND VPWR sky130_fd_sc_hd__fill_2
X_451_ _472_/A x[1] _451_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_15_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_73 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_128 VGND VPWR sky130_fd_sc_hd__fill_2
X_382_ _381_/A _382_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_40_186 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_72 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_3_0_clk clkbuf_3_3_0_clk/A _673_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_15_95 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_109 VGND VPWR sky130_fd_sc_hd__fill_2
X_649_ _468_/X _463_/A _427_/X _663_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_31_153 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__491__B _489_/X VGND VPWR sky130_fd_sc_hd__diode_2
X_503_ _499_/Y _500_/Y _499_/A _500_/A _503_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_42_60 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_83 VGND VPWR sky130_fd_sc_hd__decap_4
X_365_ _372_/A _366_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_113 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_157 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_120 VGND VPWR sky130_fd_sc_hd__fill_2
X_434_ _366_/A _434_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_13_164 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__592__A _592_/A VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__661__RESET_B _413_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_87 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_234 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__652__D _476_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_201 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_226 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_112 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_63 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_74 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA__587__A y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_18_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_234 VGND VPWR sky130_fd_sc_hd__fill_2
X_417_ _420_/A _417_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_348_ _344_/Y _345_/Y _701_/Q _704_/Q _348_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_5_193 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__647__D _647_/D VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_215 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_204 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_237 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_62 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__483__B2 _484_/B VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_11 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_75 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA__474__A1 _470_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__474__B2 _471_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_682_ _584_/X _572_/A _387_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__584__B _582_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_7_200 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_240 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__494__B x[7] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_38_159 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_137 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_126 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__660__D _505_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_39_28 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_137 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__595__A _616_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_665_ _526_/X _665_/Q _408_/X _663_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_596_ _595_/X _596_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__686__RESET_B _382_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_32 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA__655__D _655_/D VGND VPWR sky130_fd_sc_hd__diode_2
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_170 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_195 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_154 VGND VPWR sky130_fd_sc_hd__decap_4
X_381_ _381_/A _381_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_25_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_140 VGND VPWR sky130_fd_sc_hd__fill_2
X_450_ _648_/Q _450_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA__356__B1 _354_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__643__CLK _698_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_31_62 VGND VPWR sky130_fd_sc_hd__fill_2
X_648_ _462_/X _648_/Q _429_/X _663_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_16_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_184 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_143 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_121 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_579_ _684_/Q _579_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_36_29 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__666__CLK _670_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_22_176 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_165 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_154 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__510__B1 _661_/Q VGND VPWR sky130_fd_sc_hd__diode_2
X_502_ _502_/A _502_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_433_ _428_/X _433_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_42_94 VGND VPWR sky130_fd_sc_hd__fill_2
X_364_ _363_/A _364_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_136 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_169 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_143 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_176 VGND VPWR sky130_fd_sc_hd__decap_3
XANTENNA__592__B _590_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_11 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__689__CLK _692_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_66 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__568__B1 _677_/Q VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_213 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_2_0_clk clkbuf_3_3_0_clk/A _659_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_42_249 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_86 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_249 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_227 VGND VPWR sky130_fd_sc_hd__fill_2
X_416_ _422_/A _420_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_347_ _347_/A _350_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_38_3 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__704__CLK _698_/CLK VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__663__D _663_/D VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__444__A2_N _438_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_23_96 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_52 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_197 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_8 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_219 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__658__D _498_/X VGND VPWR sky130_fd_sc_hd__diode_2
XANTENNA__474__A2 _471_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_230 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_241 VGND VPWR sky130_fd_sc_hd__decap_12
X_681_ _681_/D _681_/Q _388_/X _695_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_34_73 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_245 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA__461__A1_N _456_/Y VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_37_171 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_215 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_97 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__595__B x[21] VGND VPWR sky130_fd_sc_hd__diode_2
X_595_ _616_/A x[21] _595_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_664_ _664_/D _507_/A _409_/X _663_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XANTENNA__655__RESET_B _420_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_26_119 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_108 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_152 VGND VPWR sky130_fd_sc_hd__fill_1
XANTENNA__671__D _547_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_40_122 VGND VPWR sky130_fd_sc_hd__fill_2
X_380_ _381_/A _380_/X VGND VPWR sky130_fd_sc_hd__buf_1
XANTENNA__356__B2 _355_/X VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_15_31 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_42 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_86 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_240 VGND VPWR sky130_fd_sc_hd__fill_2
X_578_ _681_/Q _578_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_647_ _647_/D _456_/A _430_/X _663_/CLK VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_16_130 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_174 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_177 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
